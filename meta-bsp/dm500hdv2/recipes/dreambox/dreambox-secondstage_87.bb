require recipes/dreambox/dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "0d922de29c8df38cb87c1c99cfe43ba8"
SRC_URI[sha256sum] = "277d69a4d82493fb30a497887b78f91a4addcba3ff1be2fb14b1cd8d0df1b8ce"
