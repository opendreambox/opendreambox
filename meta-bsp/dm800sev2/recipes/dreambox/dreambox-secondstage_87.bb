require recipes/dreambox/dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "efce7519c1386fcf107dfa34c5c46d0d"
SRC_URI[sha256sum] = "620503be42d81dec983bb44e8791bbfeea331316185292dc925c9775c57cdbaa"
