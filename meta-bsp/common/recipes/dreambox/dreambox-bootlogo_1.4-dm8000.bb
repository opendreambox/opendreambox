require dreambox-bootlogo.inc

SRC_URI[dm8000.md5sum] = "a301e3eabae31814f78859f08398118c"
SRC_URI[dm8000.sha256sum] = "cc838e257a1ecd2045d6d16a9a4358b9cb5864dc60f8ce9258b27c3ef9c07543"

COMPATIBLE_MACHINE = "^(dm8000)$"
