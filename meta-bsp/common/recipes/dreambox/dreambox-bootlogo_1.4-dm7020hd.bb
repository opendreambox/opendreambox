require dreambox-bootlogo.inc

SRC_URI[dm7020hd.md5sum] = "8ec81750eb4f5456923706eadfbd5182"
SRC_URI[dm7020hd.sha256sum] = "24700313a856677a9503117423f8b718af7ceeaad0f0642421ba3b31f4c60e92"

COMPATIBLE_MACHINE = "^(dm7020hd|dm7020hdv2)$"
