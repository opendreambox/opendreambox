FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

PR .= "-bsp2"
