FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PR .= "-bsp1"
