PR .= "-dream1"

SRC_URI += "file://remove_gets.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"
