RDEPENDS_${PN} = "opkg opkg-collateral"

require packagegroup-pkg.inc

PKGTYPE = "ipk"
