FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-gio-add-g_socket_join_multicast_group_ssm-IGMPv3-SSM.patch"
