FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

PR .= "-dream0"
