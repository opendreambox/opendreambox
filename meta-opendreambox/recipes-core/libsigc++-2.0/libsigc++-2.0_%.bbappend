FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-Revert-signal-Use-the-slot-R-Args.-syntax.patch"
