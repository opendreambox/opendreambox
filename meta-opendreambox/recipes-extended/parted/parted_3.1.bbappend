PACKAGES =+ "libparted-fs-resize"

FILES_libparted-fs-resize = "${libdir}/libparted-fs-resize${SOLIBS}"
