PV = "0.3.93"
PR = "${INC_PR}.0"

SRCREV = "0cf00a4fe8559271ff1fd92cf5a503f1701739e0"

inherit qt4e

require qxmpp-git.inc
