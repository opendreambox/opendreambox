inherit qt4x11

require qxmpp-git.inc
