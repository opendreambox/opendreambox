require blindscan-utils.inc

SRC_URI[mips32el.md5sum] = "06157669c22162333839cedeb4ad09cf"
SRC_URI[mips32el.sha256sum] = "0b6fdaa1bbc594d0bae5c855032130956da98b05a8d9a23b950983dc3f40f550"

inherit opendreambox-precompiled-binary
