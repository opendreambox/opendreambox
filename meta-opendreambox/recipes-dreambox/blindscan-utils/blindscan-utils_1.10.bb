require blindscan-utils.inc

SRC_URI[mips32el.md5sum] = "7c10e9d5c58e2bcf2ffd20da18c3ced1"
SRC_URI[mips32el.sha256sum] = "d25b423e2907cf6165d14a4b39076be402a00be14bd5eb99cad4b0f97fc693ad"

inherit opendreambox-precompiled-binary
