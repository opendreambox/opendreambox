SRC_URI[aarch64.md5sum] = "31472e221b3b6d60eb3fb5671d0da8e2"
SRC_URI[aarch64.sha256sum] = "9d353ac924f7c23391e4bc70bacd31808eccbb95d63161b777a12c52371c88e8"

require enigma2-bin-4.3.inc
