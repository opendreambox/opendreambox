PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "8dca747cdc06866435af1016a94b4ef0" 
SRC_URI[mips32el.sha256sum] = "d6e234ae0bc4b360e0109fbd01db799a5176938d6fbaf135f2d090dd3f2ef9f9"
SRC_URI[mips32el-nf.md5sum] = "f40db68a85b06d03d12cd859a7e0409e"
SRC_URI[mips32el-nf.sha256sum] = "872909f576cc7fe512a8432782306d0c99666490d7b3494ff46c3697de1c3ef4"

require enigma2-bin-4.0.inc
