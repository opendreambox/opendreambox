SRC_URI[armv7ahf-neon.md5sum] = "d0dfd733cfa85c448def2ec047804087"
SRC_URI[armv7ahf-neon.sha256sum] = "967fa256d09035ac64ddd0da57c7cad4e83b700779e91ae837b2f916c9663cc3"

require enigma2-bin-4.3.inc

COMPATIBLE_MACHINE = "^(dm900)$"
