SRC_URI[aarch64.md5sum] = "932d6e30ff39cf5e2c3699f55ac0867f"
SRC_URI[aarch64.sha256sum] = "5b0b0a567e31e8195d4e18cef591ba9c246feea3bdd631df717e53400443e236"

require enigma2-bin-4.3.inc
