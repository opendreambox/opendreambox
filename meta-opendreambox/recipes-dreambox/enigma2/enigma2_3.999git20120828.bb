PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "6d64bd04500ddf75cda727845e4850f8"
SRC_URI[mips32el.sha256sum] = "e1c1385efbf9b9733f7393c80c02f0d2207bdc6dba1000cd9918125e9dc4ff66"
SRC_URI[mips32el-nf.md5sum] = "50e94d430dc633920193eb77a5cc3f37"
SRC_URI[mips32el-nf.sha256sum] = "c11ee4b812b5288d7e8d97e84da6c3dbd80c3e24651c75669281fd05558894b4"

require enigma2-bin-4.0.inc
