SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "e4742f3082d6253205a4d456dccf3e4d"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "b3d2baa23a1a6559274b99f89acff1a327c3b4dde591262b46185ec36d869881"
SRC_URI[mips32el.md5sum] = "9791d4e8969168266a0039cf53e567fc"
SRC_URI[mips32el.sha256sum] = "1b148c90370ee74c406b6e4e0e9acedf7faa2a1d4f06d57e866ef6dd3095efa9"

require enigma2-bin-4.3.inc
