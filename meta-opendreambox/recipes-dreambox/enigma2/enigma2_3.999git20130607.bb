PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "639678e55faa92a78882b31455fba48d" 
SRC_URI[mips32el.sha256sum] = "3467b92a41e607576573a91e308cd2cec8cb1693714e3ade9b379ee4789cc11f"
SRC_URI[mips32el-nf.md5sum] = "e2282bcfc94e1df5f00b34f5655c680a"
SRC_URI[mips32el-nf.sha256sum] = "5d569217ae7d62e011d57ee6f8baa64ad8ef175a6f5ca887597ff11d3ae2f5d6"

require enigma2-bin-4.0.inc
