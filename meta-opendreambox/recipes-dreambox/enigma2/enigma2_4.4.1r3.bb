SRC_URI[aarch64.md5sum] = "fd349fc8bae82f480cd0d0027626c650"
SRC_URI[aarch64.sha256sum] = "1180661483d252c4b79631e92c984c4d491198c6b0f9e496eda79a4ac038bb8c"

require enigma2-bin-4.3.inc
