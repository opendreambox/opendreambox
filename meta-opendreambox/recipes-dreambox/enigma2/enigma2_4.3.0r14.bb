SRC_URI[armv7ahf-neon.md5sum] = "84c4b8fe05feaf0bdcde0294e0de898e"
SRC_URI[armv7ahf-neon.sha256sum] = "dcf84902f96b2bebfa48c20d246d3872601dd9ea7a0adf1de8d753e68b01c992"

require enigma2-bin-4.3.inc

COMPATIBLE_MACHINE = "^(dm900)$"
