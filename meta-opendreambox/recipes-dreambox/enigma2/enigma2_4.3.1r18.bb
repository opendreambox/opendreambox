SRC_URI[mips32el.md5sum] = "2de9fb82c56881baa03e4b5075d91fee"
SRC_URI[mips32el.sha256sum] = "10012677a381eba65dc8737d5109d1f4977d4d98c617fb6f4a0daae19c6aed3e"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "70f682e466e4cc454b3d4693d458be32"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "046372eefdb6170e2f85df0315a26c276056b60efe4199a8a61c786dc5350d43"

require enigma2-bin-4.3.inc
