SRC_URI[aarch64.md5sum] = "55b582d11e066afc07906bc041dffe24"
SRC_URI[aarch64.sha256sum] = "1062529ad4e39526541847227935abbe97204a9986d604f7d0089cc41fa3835f"

require enigma2-bin-4.3.inc
