
SRC_URI[mips32el.md5sum] = "3f80b3c00edf86a475cacaea1bed09b3"
SRC_URI[mips32el.sha256sum] = "7723eec931a87cb30e094125f70e8b05777d1bda37e983d96369f0a08cfc1d0a"
SRC_URI[mips32el-nf.md5sum] = "b9ac9d9701d3df14aedeb1e5314a726c"
SRC_URI[mips32el-nf.sha256sum] = "36948367f2834543ef568dd98c49fde771428c06ee09c898dbff3140e83c376c"

require enigma2-hbbtv-plugin-bin.inc
