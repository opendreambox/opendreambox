SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "fafd1bda94a3e033f9ffa3b30ca28526"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "db8f8350f7186a2fba883bc77ce5a8ea30a125f6c027e132de57d208ca40656b"
SRC_URI[mips32el.md5sum] = "3d2b57397f16e299b146951cd0a58c21"
SRC_URI[mips32el.sha256sum] = "04c886bfa55a167f75beedaa28002895930f6c8e5bcb1b47b664c5f2dcd25253"

require enigma2-bin-4.3.inc
