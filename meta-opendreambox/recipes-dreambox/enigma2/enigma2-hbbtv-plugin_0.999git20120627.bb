
SRC_URI[mips32el.md5sum] = "dbcbece33314f9793e14c817b2f735c6"
SRC_URI[mips32el.sha256sum] = "c17223b562a46f69f93e2c39619c7c4a9b374128298a6ea354d30744e0bc086c"
SRC_URI[mips32el-nf.md5sum] = "45a2b80897766fe0fc67846ed90001d6"
SRC_URI[mips32el-nf.sha256sum] = "acdfe2d35db8dec5caf6a56192acb45b45dc1db617fe28be6c594833aacfe2e5"

require enigma2-hbbtv-plugin-bin.inc
