SRC_URI[armv7ahf-neon.md5sum] = "8e09e2c0baa2a49f617554f106026fba"
SRC_URI[armv7ahf-neon.sha256sum] = "35b6edacc41136d9eab081fa8570d229eed0ce36548a366155d3f982bfbf9b84"

require enigma2-bin-4.3.inc

COMPATIBLE_MACHINE = "^(dm900)$"
