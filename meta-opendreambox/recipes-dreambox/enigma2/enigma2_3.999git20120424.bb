PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "770556187a1b0352ef541c35230ef7f4"
SRC_URI[mips32el.sha256sum] = "c4c9324a52daa13306e27cf92c3f5bc371059c338147cca19f4ba5ba3f4ae765"
SRC_URI[mips32el-nf.md5sum] = "434f40a28889bbd9a77216e8ac8cce14"
SRC_URI[mips32el-nf.sha256sum] = "3cc85bebb2946b5e8383f942d2d143290c130151f7b31852a028db114fa05bda"

require enigma2-bin-4.0.inc
