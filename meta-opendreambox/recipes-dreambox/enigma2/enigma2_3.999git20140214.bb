PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "cba6fe6861194ecbf487af198a75dbb1"
SRC_URI[mips32el.sha256sum] = "e4f797a56c554e380626e08f6276fe8868f184d09736f7644f12b94268a1fc63"
SRC_URI[mips32el-nf.md5sum] = "597770b1be9ba9a9a9dfe5649b8df267"
SRC_URI[mips32el-nf.sha256sum] = "71f4b84f1badfbd9edffe84707d82f8b3ad3ea85381f8c82c92ae845c671a7de"

require enigma2-bin-4.0.inc
