PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "18972731b7cf3a0e4fabead4731da4b9"
SRC_URI[mips32el.sha256sum] = "e10203d679a6e20a6a6201c54ad76eaf3bb16942e11fcbc1bdbc1b7de402309e"
SRC_URI[mips32el-nf.md5sum] = "9236ccde579a1db9f6ac26b1fbd9dee1"
SRC_URI[mips32el-nf.sha256sum] = "371e53df2c772cad1a398cdb1438846763fa0e3440653b187877a61f21e1890b"

require enigma2-bin-4.0.inc

