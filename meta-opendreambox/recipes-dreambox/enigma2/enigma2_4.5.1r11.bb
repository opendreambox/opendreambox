SRC_URI[aarch64.md5sum] = "64ca3bf794532f109b20ecd8cb58216d"
SRC_URI[aarch64.sha256sum] = "4dfe1c318feff48b01585eaebfb82e2d7e3ef368b65844c8270ce9c1beb8276b"

require enigma2-bin-4.3.inc
