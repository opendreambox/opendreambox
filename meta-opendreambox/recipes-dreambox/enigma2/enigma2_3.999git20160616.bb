PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "296555a5c843680261dd99bfc81f83de"
SRC_URI[mips32el.sha256sum] = "ecd9bedd2c8e15044733865bd16dadf092dd967656e145bf63170cfad4bb13df"
SRC_URI[mips32el-nf.md5sum] = "519602bfa33e633c504ff0cec310bb01"
SRC_URI[mips32el-nf.sha256sum] = "975983e449b90b1b398b36558c2df4a1a41769460f04e3e2bbe5ae483a987db7"

require enigma2-bin-4.0.inc
