SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "90600322bedf8d32f5c560520115f649"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "fc67da2c93ce3bd2e64d8d81f9d6895fe5eb1e6be65b04ef63f5b6f2df24cb32"
SRC_URI[mips32el.md5sum] = "e730499635970056fc3188d95b36f208"
SRC_URI[mips32el.sha256sum] = "61760eb7fc1e7d603570dbfd1388a2948a683cfdc7c71a9cf4adc5eabe3436aa"

require enigma2-bin-4.3.inc
