SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "b2ccf7f65f2ba46ecdf735c70a88cd65"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "e343c7e8f8cafd1d189b10c0f9281e7a8feab869239cd0e4345184215e70332a"
SRC_URI[mips32el.md5sum] = "8a35d37afb9edf3d900b311ad2cc9bba"
SRC_URI[mips32el.sha256sum] = "4a77ee5859fb7728b57da3ce3b3052a71be8f63717cffdb080ff41239cb41de5"

require enigma2-bin-4.3.inc
