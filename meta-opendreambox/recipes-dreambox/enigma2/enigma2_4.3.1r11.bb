SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "cecb5911a1925da4925ee052c050cb9e"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "32e27c676c11875280d07a2a06f831fd28a812f65486846eca58009cc7fcbaac"
SRC_URI[mips32el.md5sum] = "60eaf72f739c47d90738fbc1af28d0df"
SRC_URI[mips32el.sha256sum] = "841f76c07ca526222d47444e9dc351f9ae14b9996a6800dc3c35559ab4b9e981"

require enigma2-bin-4.3.inc
