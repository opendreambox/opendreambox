SRC_URI[armv7ahf-neon.md5sum] = "df7dcc9871d2428b60d0708c9a82ab43"
SRC_URI[armv7ahf-neon.sha256sum] = "a3059eb13e4140ccca3c8a0030b44aeea3a86766807437fb51096e3fecc3fd28"
SRC_URI[mips32el.md5sum] = "3780ba9c6830f94fb3beaa6e961c68b3"
SRC_URI[mips32el.sha256sum] = "3059df4d1c9b6e6bd682702b6a89b419f28894474f4975db03396582ce6dcbfd"

require enigma2-bin-4.3.inc
