SRC_URI[mips32el.md5sum] = "d5f292444160e48127ad1a5ce4669eab"
SRC_URI[mips32el.sha256sum] = "4df6ddaf49890ae8b079f1f6c0e8a5c1dbd32b5758f87937b37e8a68896f24c7"
SRC_URI[mips32el-nf.md5sum] = "8a00b8df98e3494d90430614a72d52cd"
SRC_URI[mips32el-nf.sha256sum] = "1a09cd4fdc79b5d71160193017ec1c02715e09d36191f7b7d6170428e94bf76b"

require enigma2-hbbtv-plugin-bin.inc
