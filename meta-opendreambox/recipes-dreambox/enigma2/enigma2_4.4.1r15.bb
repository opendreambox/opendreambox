SRC_URI[aarch64.md5sum] = "23b0c031a224a76fb8f1d5cd10a4aa76"
SRC_URI[aarch64.sha256sum] = "5e15c2752cb044db7961bfdfb33f61a8f3b3e9b07b26e37d488a4ff0a01eacb3"

require enigma2-bin-4.3.inc
