PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "384b9321427eaa2169faa20f23dffe31"
SRC_URI[mips32el.sha256sum] = "bc45749f18762d3fec16d9b3647f1f78f58c22d115875008ea6c9bb83d40f7a8"
SRC_URI[mips32el-nf.md5sum] = "54f2ec58266228bd61d159373fedb349"
SRC_URI[mips32el-nf.sha256sum] = "e85a591fcec5b1c13dabc8629a344424d096e48c1650d61383d7fe8c59a6ec75"

require enigma2-bin-4.0.inc
