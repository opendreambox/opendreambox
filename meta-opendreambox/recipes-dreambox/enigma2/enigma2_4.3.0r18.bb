SRC_URI[armv7ahf-neon.md5sum] = "8c22ed50f6df2c77ed0fc5dab43050d2"
SRC_URI[armv7ahf-neon.sha256sum] = "50fb78eba1b8bda9a960d7b5e53598cdcfed668edc38829ddd513e9e3cbe459d"
SRC_URI[mips32el.md5sum] = "287f9238559c01fe12349bba1b7f0cc1"
SRC_URI[mips32el.sha256sum] = "91ffc57c39813d309713d92353efd3dbfab0bee22a0f3892614af67cf60f5ca4"

require enigma2-bin-4.3.inc
