SRC_URI[mips32el.md5sum] = "d80a250387e3f25c992935786952ad32"
SRC_URI[mips32el.sha256sum] = "69a5cf2f67dcba65e60e6e375263357f8defd472094fb85312d384e7010b3b08"

require enigma2-hbbtv-plugin-bin.inc
