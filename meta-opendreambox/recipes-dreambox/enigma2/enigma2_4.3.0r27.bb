SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "394c2d88118a5fad7d5092e14439baeb"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "057684e58d003efc46c32cf9ace5edac2e4d1e4f8a5a5948c0990d58bece8b15"
SRC_URI[mips32el.md5sum] = "24369f4ae1479bc129e3208a996a56ab"
SRC_URI[mips32el.sha256sum] = "9922f3f9425757795a7e36f420fef818e56a09e7e3a8828a75a9095e5fb40b1c"

require enigma2-bin-4.3.inc
