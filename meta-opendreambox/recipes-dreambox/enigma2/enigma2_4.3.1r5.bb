SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "b2b1d60d80abcbd8d20835cbc958a446"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "1c9a1f447545604e1c719e8e321eec8913510df294b17a8d4c32d8eeb8b54839"
SRC_URI[mips32el.md5sum] = "0b868808b0a437a339f1bbfa5dfe0a74"
SRC_URI[mips32el.sha256sum] = "8902e65bb2334859f97ddb461d80db414cf3e3cbc62eed33e953b8949aea7b77"

require enigma2-bin-4.3.inc
