SRC_URI[aarch64.md5sum] = "d23aa6c799326154658292d69b210fca"
SRC_URI[aarch64.sha256sum] = "3d7b6b46a24146ea8b590be794c7eb5ff135a0f5f85212d3ed1c7b24cb166775"

require enigma2-bin-4.3.inc
