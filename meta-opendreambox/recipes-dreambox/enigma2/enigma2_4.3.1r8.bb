SRC_URI[mips32el.md5sum] = "abb78976bbc3130366be41f5228a22ac"
SRC_URI[mips32el.sha256sum] = "257b2dca11ee42b0fe2d3fbd54e75c84e213c35129045886a883e9c39b98b8e7"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "ff11b1a18f26915685e944194abfe07a"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "9408b67da04ad3be4a66a3d0392cc5e0541c9324a3d16510707492f6d8a5cb8a"

require enigma2-bin-4.3.inc
