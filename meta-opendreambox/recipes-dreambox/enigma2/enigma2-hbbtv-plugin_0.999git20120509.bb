
SRC_URI[mips32el.md5sum] = "eb34d410d634dbaa213c5fa8cd526b3c"
SRC_URI[mips32el.sha256sum] = "43a54827797fe4457fcd4f543553bec7bdd8fb4b0719ba6b0b15bc94c516d76f"
SRC_URI[mips32el-nf.md5sum] = "9c13c038d8871ec45b732a4f5a466f73"
SRC_URI[mips32el-nf.sha256sum] = "a848674adb2049e5149707bd12cc21c12a89bcb591d1297c9eed8e89abc704ab"

require enigma2-hbbtv-plugin-bin.inc
