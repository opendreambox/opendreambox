SRC_URI[aarch64.md5sum] = "868b0a25073cbe7712f01f438c89b5e9"
SRC_URI[aarch64.sha256sum] = "74b6418593b5f4512fb2206023c69ecb7977a34da68548d89d64595c19d5d133"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "8a40104007428f466aee1f062ba43558"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "ee0cb589763090abfd14cced3aaaea455f64d4993cc58ec236548c8f0eaed944"
SRC_URI[mips32el.md5sum] = "fffdac0a140f0f0d19d4129214749191"
SRC_URI[mips32el.sha256sum] = "6cd2dab950eb1cfb950cd06661166b4d5b363da54fb78f2b0c20a8a8191e12d0"

inherit opendreambox-precompiled-binary

require enigma2-hbbtv-plugin.inc
