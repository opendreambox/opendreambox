SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "f57d0fd917fbc5e4fc97d55e7eae0d79"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "6437a3939d0d8a370f7e313203b74081f39c974c66e5fb5160d11fdd8849de96"

require enigma2-bin-4.3.inc
