SRC_URI[aarch64.md5sum] = "4a184e68f0a3ef295e35f1f346cae4ba"
SRC_URI[aarch64.sha256sum] = "ed00081a107b5b370c7aecd408f3e4e8984e72e9a6146fc12dea2699c24e5f01"

require enigma2-bin-4.3.inc
