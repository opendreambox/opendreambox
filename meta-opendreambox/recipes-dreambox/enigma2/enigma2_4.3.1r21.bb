SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "d5948a3ffd9a0ba0d7f82aae8b1ad16d"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "2f184b721f0aef03b33d1c2bf6c7324ebacf500b279e5ad35ca13290f07f339f"
SRC_URI[mips32el.md5sum] = "52bb3dc964e35490a3446234961f82e7"
SRC_URI[mips32el.sha256sum] = "961c1ef59de83248139757a81e22b03832cd38b018bfd5e72a4e3e7c92b2a07f"

require enigma2-bin-4.3.inc
