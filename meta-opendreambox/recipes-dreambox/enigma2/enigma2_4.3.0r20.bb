SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "eee5e1d8defe0b96929f5bef83964bb8"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "0033d7c04a7b15f30dcc08f6690634685f20e1074d1ef4f3e8eaee8936d00eb7"

require enigma2-bin-4.3.inc
