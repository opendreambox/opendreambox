PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "f9739e4849dd98f97dac718c0dc20864"
SRC_URI[mips32el.sha256sum] = "d41246204d3eb41c7b82f639a40986d2911222018f7511a7a18019edf86780ca"
SRC_URI[mips32el-nf.md5sum] = "099417548bfacaa714ad2632f1beca31"
SRC_URI[mips32el-nf.sha256sum] = "69fc701e58e25a476a3758e09a1d919716b072a9125ac5a061f514417caefc40"

require enigma2-bin-4.0.inc
