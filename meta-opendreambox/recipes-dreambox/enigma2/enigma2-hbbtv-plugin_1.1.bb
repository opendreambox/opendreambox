SRC_URI[mips32el.md5sum] = "4e30a621a1d77ebec648e4d0b8542ccf"
SRC_URI[mips32el.sha256sum] = "ff0b2716cf78713636d9f3bc2a8f05260ef556874d5e8bf7a6b901ce59b80301"

require enigma2-hbbtv-plugin-bin.inc
