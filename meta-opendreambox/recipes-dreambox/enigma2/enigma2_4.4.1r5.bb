SRC_URI[aarch64.md5sum] = "348d915ffec9b91aff6d2159a5c4aaee"
SRC_URI[aarch64.sha256sum] = "1a9dfd7e404dd868c0461e84e94f0ed24136b5ae72420ca2139df578a047c4ed"

require enigma2-bin-4.3.inc
