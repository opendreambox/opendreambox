SRC_URI[mips32el.md5sum] = "99d431296cf4cfbbdf640b59eeb38655"
SRC_URI[mips32el.sha256sum] = "d5b645c333052feee51c31834c3a46f345324dd4358906b6b0eddaba38c7a253"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "4b900ccbf780b2e84ecd7c51c24e9f87"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "7667f1126ee1c71f129c4222e24533e9e2246bc4441fd4e1de0fce77dcd79a72"

require enigma2-bin-4.3.inc
