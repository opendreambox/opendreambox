PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "e7ce8bb260f667ec39f88be6a4176f2e"
SRC_URI[mips32el.sha256sum] = "0afa4480bcded9b5cc6a567274e90f16368fd49996c1653bf6886709503d86d4"
SRC_URI[mips32el-nf.md5sum] = "058924e0119ac87a13b8ca9b3d4aa2b0"
SRC_URI[mips32el-nf.sha256sum] = "9dce5bbf48f3c89e3241f78a522f8e47c51c4d54eb7d3952d737e161d3aadfcf"

require enigma2-bin-4.0.inc
