SRC_URI[aarch64.md5sum] = "4d1d2e8c5718c29fbf251966606db404"
SRC_URI[aarch64.sha256sum] = "dad350d3e27c5877603c8b5ba703920179a5d8e4303ab79b769dd38a4874b94e"

DEPENDS += " pugixml libwebm"

require enigma2-bin-4.3.inc
