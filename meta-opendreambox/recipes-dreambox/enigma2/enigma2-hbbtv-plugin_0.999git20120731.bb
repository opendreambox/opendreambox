
SRC_URI[mips32el.md5sum] = "650286a459b0e260b56059a114c970e9"
SRC_URI[mips32el.sha256sum] = "442f4d91bf646d259c0f7e95dffa17222d3ceb8c02ec5928f5380ef77add8b16"
SRC_URI[mips32el-nf.md5sum] = "6d11dc5f7dd50fb09b61e27027718487"
SRC_URI[mips32el-nf.sha256sum] = "73a977ab11c7b4a0feeccf68cd1b62c0114ebf7283b66c0311aeabdd47139b22"

require enigma2-hbbtv-plugin-bin.inc
