SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "9a72311794567bec0faaa9b9c10be84a"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "703fb1723fcdbd9aacc4d743f8e91a5a56e89637abfe1e84e5a3929051c0ae81"
SRC_URI[mips32el.md5sum] = "d25f10b942d0fcbfef35864df071d0f4"
SRC_URI[mips32el.sha256sum] = "95e6e834fcd926b42b07efec58abde3f2351ced5ffd448893aeb74c711687ef0"

require enigma2-bin-4.3.inc
