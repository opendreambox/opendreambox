SRC_URI[aarch64.md5sum] = "bfc8a98914ce0890fba1c9965da02589"
SRC_URI[aarch64.sha256sum] = "f06a7486e03107f50cb79aba12dd9bd9a525a7a44626d91de8af6b9210f6c22d"

require enigma2-bin-4.3.inc
