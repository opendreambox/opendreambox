PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "5dd4aa1368b1777d6cbad23cf9579e6a"
SRC_URI[mips32el.sha256sum] = "496e7d6acf4e9bd5bfb81ef41e326b844114d68c82df0998fc481a913f6091d9"
SRC_URI[mips32el-nf.md5sum] = "44725512d834ae02882a64422dea8509"
SRC_URI[mips32el-nf.sha256sum] = "fffe57e68f4135337147d77b7571318b0dc0710ecd8e7f330d6d3a476692a2d7"

require enigma2-bin-4.0.inc
