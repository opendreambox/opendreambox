PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "eded5e1cc251a2168fc34567d36bf32b"
SRC_URI[mips32el.sha256sum] = "d34937b18bc4cf45a26c1d3f9e13b94f24987b8a84a855aba8bc5ecaef371f2a"
SRC_URI[mips32el-nf.md5sum] = "ddc73347e9e493a3e1988ecf16c09638"
SRC_URI[mips32el-nf.sha256sum] = "e2ee7ff6a07d6ad8b941edf7738280a8b011678e5eccb728bbd2002c08402495"

require enigma2-bin-4.0.inc
