SRC_URI[aarch64.md5sum] = "cd5d3b7158f837ceaaca23fc49352c3a"
SRC_URI[aarch64.sha256sum] = "f551dda1244dd3556d954b484c815fd92136dc9f0b50a6f5434ab63bdfc90215"

require enigma2-bin-4.3.inc
