SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "447d1e07cc7cbb0d4be586244fae0ff3"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "b65090a5668322ccde401432a881e745d031bb5af88028a37e09be10227cd498"
SRC_URI[mips32el.md5sum] = "cc89f616633cd5ee276dbf4bc51c0ce6"
SRC_URI[mips32el.sha256sum] = "f35ed8302418f58062b84efe3852eb1481c2c9a3bcf48bb8c73acf55f64a3823"

require enigma2-bin-4.3.inc
