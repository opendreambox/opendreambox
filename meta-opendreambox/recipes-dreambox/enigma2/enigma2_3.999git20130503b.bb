PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "05a5ddcaceaad0d9f7332c4b6da10259" 
SRC_URI[mips32el.sha256sum] = "951a92c3760ddc197cd3ff4222f1c6097880809da1ec55d77159f397bf37f987"
SRC_URI[mips32el-nf.md5sum] = "bbd2f03d164f2eea6a11f045230a0719"
SRC_URI[mips32el-nf.sha256sum] = "01f216c3ad67d303cc5ccc14c7f2049d8fc046ae4f94d26dd7c24bfb9e526489"

require enigma2-bin-4.0.inc
