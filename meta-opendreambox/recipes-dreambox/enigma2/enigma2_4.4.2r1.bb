SRC_URI[aarch64.md5sum] = "e78770f65cf11ef00deb4537eda55b25"
SRC_URI[aarch64.sha256sum] = "d40d52fa002c4cca315bcc397501ea6eee8baba9962ab247deb9aa3ff34b776f"

DEPENDS += " pugixml"

require enigma2-bin-4.3.inc
