SRC_URI[aarch64.md5sum] = "9684557a6666a8fbc4fb2b36e38118a9"
SRC_URI[aarch64.sha256sum] = "cfa4e6ac6e6fec1a346dc85de7f0feba3025a4842840948e22ba2bbc978691f4"

require enigma2-bin-4.3.inc
