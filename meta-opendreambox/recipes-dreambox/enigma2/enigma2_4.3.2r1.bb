SRC_URI[mips32el.md5sum] = "f7a2c5d3df216967457f8f30b8732aad"
SRC_URI[mips32el.sha256sum] = "f03e486b5a27251fce14b18643bbcee4aa38171e255aaca44fcc69e3b292e287"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "5cc5dfc5e75d0bd72be0ecd825609372"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "43766f4f65d8298c59cc34386a00ca1cc807bcdea5e9a699150de767e4160fc0"

require enigma2-bin-4.3.inc
