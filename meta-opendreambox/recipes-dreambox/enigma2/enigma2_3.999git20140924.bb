PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "2282470d3f249aab63a5121e05e0b18a"
SRC_URI[mips32el.sha256sum] = "588ef50a669b55255166d4bf3b2abdb26f6e0f674abb924b67ebacd78865b30f"
SRC_URI[mips32el-nf.md5sum] = "3f3ccfa60c60f1f7914c157989703bd4"
SRC_URI[mips32el-nf.sha256sum] = "f157cdd437f990e9161923be6014c668d54f65e702889fee5d076ec6488f6071"

require enigma2-bin-4.0.inc
