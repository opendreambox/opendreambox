PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "e972373150f614f3bfeb65f2c1ce0a01"
SRC_URI[mips32el.sha256sum] = "2294f078af49ae7ae514ca9c8da4dbeef561f9a63acc161292395a215885b970"
SRC_URI[mips32el-nf.md5sum] = "bdfeffd32722b735bb3c391abb65de0c"
SRC_URI[mips32el-nf.sha256sum] = "0b2f17da134b4f17390a56468f12da506c550190b096ee3a3f135971d25b84e6"

require enigma2-bin-4.0.inc
