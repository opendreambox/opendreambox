PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "e99088b41b7acde87c817ad88f59cfd5"
SRC_URI[mips32el.sha256sum] = "6f006668a8be14f35453f720fe5184e54598081d40b23827df4cfdd6e3705bcc"
SRC_URI[mips32el-nf.md5sum] = "a741132740621296001b8d0f72a09982"
SRC_URI[mips32el-nf.sha256sum] = "8ac4d37ef6c8746d79027fd3bed5975e1be7b32eba4eaf992b905ee4e263293b"

require enigma2-bin-4.0.inc
