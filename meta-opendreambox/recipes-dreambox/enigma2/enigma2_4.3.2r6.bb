SRC_URI[mips32el.md5sum] = "f2cdf2a290f4d9497228a01b7c136dd8"
SRC_URI[mips32el.sha256sum] = "d03cfa7f6f7fe65989debbfaceafeeb8b0ed6582e44167d2c91a8d0872684293"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "ef3e875ab1a63873ffdf7634e4840803"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "5a7e2995b8d28c9a9cf3d58cd98c4324d1ebb396752b96fd659930e0d7ac2dc4"

require enigma2-bin-4.3.inc
