PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "8885c7f40311463bb0396a5ee59320a0"
SRC_URI[mips32el.sha256sum] = "6535b8c2e33c994d3dea9b60c39401b5ea353f94a13301a63f869f707ba1db28"
SRC_URI[mips32el-nf.md5sum] = "155d22571cd62c22ccf77e37f9682d5a"
SRC_URI[mips32el-nf.sha256sum] = "36b3c3ad386aa37e7d323fa417b36ef7ba1a4202c30a4e40cb19cf9d891e14f5"

require enigma2-bin-4.0.inc
