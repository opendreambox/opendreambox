SRC_URI[aarch64.md5sum] = "17c3c94fc26ec5f73ee625b2d2a1e4fb"
SRC_URI[aarch64.sha256sum] = "0377a89c0e5ea873f77e3df643c5c4e88101eec2cff1c149dcb1bfe9fc142c74"

require enigma2-bin-4.3.inc
