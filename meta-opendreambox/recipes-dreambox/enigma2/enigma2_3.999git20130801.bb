PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "a601e2e189c214608cccca1af6c36c9d"
SRC_URI[mips32el.sha256sum] = "d947cc33e97da42061609a7bf120269d6ce7e5d6e067bc186db66fbefa7f7008"
SRC_URI[mips32el-nf.md5sum] = "2e660b9c505bd128d6f802a2423e00df"
SRC_URI[mips32el-nf.sha256sum] = "568ac14c3c27422163b21c035c9d2b37a73d34069f01131e5275034f3ba65d9b"

require enigma2-bin-4.0.inc
