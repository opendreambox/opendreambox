SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "8e6f9bf8255d35b73002a36e79031d9d"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "b9530751cf6d29503252676a93609f4f90cc346e9c6ddbdf727ba40104974285"
SRC_URI[mips32el.md5sum] = "b5e6bc392ea840532343cdf1d020342a"
SRC_URI[mips32el.sha256sum] = "d84dc94012f2984d90e77545ea42546fe26731db94a14f388ee3d2704bd5fbf8"

require enigma2-bin-4.3.inc
