SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "fe6c220eed99b9f1be935702ddf244ba"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "8bc6bd07aa11f28ea3cb3bd1e2a1210d600a2ef5eddbb545d3e35a693e1e4aa9"
SRC_URI[mips32el.md5sum] = "a08945809473912e821c298939fcefd3"
SRC_URI[mips32el.sha256sum] = "7244efd529f76bcb84099d94d7eab603d3618be8dfb3d79258c8c63b87b3b2ce"

require enigma2-bin-4.3.inc
