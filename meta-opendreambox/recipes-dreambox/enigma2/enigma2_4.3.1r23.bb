SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "86d936615c527cd2492e72921655346b"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "d0d2bd199da323ffc00cd58a12ba43e799dc6e0db63ac7eadc98dfa99e5c2d0d"
SRC_URI[mips32el.md5sum] = "cfadc6de7b0ff74467db48b30fda8cd4"
SRC_URI[mips32el.sha256sum] = "56870fa7a37677e1ffd854d2f6b60aa6efd1a6a600caa18317c6693c394ebcbd"

require enigma2-bin-4.3.inc
