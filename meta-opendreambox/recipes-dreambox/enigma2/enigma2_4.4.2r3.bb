SRC_URI[aarch64.md5sum] = "f3ca9670c71e2c910027461cc879eb84"
SRC_URI[aarch64.sha256sum] = "4461b28e70b312f63d64289924647b312eaab413008e97d4f726a9f2bf3af0e1"

DEPENDS += " pugixml libwebm"

require enigma2-bin-4.3.inc
