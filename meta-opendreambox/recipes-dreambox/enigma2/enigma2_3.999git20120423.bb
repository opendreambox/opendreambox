PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "e3159061e088b8b01e283b80db739add"
SRC_URI[mips32el.sha256sum] = "f959a59105db52a24602e55a04488adefe5f46ba5b3c8b49c123bf58850d41f9"
SRC_URI[mips32el-nf.md5sum] = "a73f0b37b4fcb746bf2bca0b55848ad7"
SRC_URI[mips32el-nf.sha256sum] = "a95c8f4d1d479b6ea27e3943a94470e1bbedc842b8177eb9ae40d3947631f1cc"

require enigma2-bin-4.0.inc
