SRC_URI[aarch64.md5sum] = "1b8c490e89da2f0249234330275297b3"
SRC_URI[aarch64.sha256sum] = "12d1da0da833c43cf4cea5bfad23be1c726a00916fec3c64cb5051c4efd628f5"

require enigma2-bin-4.3.inc
