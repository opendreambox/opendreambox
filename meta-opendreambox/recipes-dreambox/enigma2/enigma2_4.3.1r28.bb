SRC_URI[mips32el.md5sum] = "162ceef2018171a480c33ca6562e4819"
SRC_URI[mips32el.sha256sum] = "da3e26934e2ed048628a89db0fcef16b9ecfe78f5a67b4c85ac31f4deb495213"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "5370560f78b91582b2c02b8ea59b367e"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "1128667f429d8ae47001d55e125b16ff817959cb1e4f7aecb31ee658e3c5b9ef"

require enigma2-bin-4.3.inc
