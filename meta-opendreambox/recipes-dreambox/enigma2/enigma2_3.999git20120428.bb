PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "530d6b138f66630ac0686fe161a69d25"
SRC_URI[mips32el.sha256sum] = "f1d4ad3d8fe71219f643f136ad0e3c7833d4441c945a1ed74ad0999e5fab8016"
SRC_URI[mips32el-nf.md5sum] = "13214cc68ec79fa6aa9d6f74f35fbc4c"
SRC_URI[mips32el-nf.sha256sum] = "66ba262df6b1c7c33154fef8a31379294342bac0d14b4bc0bd387f647346e8b0"

require enigma2-bin-4.0.inc
