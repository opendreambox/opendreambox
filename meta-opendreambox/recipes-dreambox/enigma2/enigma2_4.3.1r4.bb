SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "65f0343cff93c889452f2768aebd5a2c"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "ca74b8f57d59580cf4f927b01a3d3132b64b8fb1b504800e3d4065bbd2d9ddf1"
SRC_URI[mips32el.md5sum] = "68391644403d0263d0b55a6f60140459"
SRC_URI[mips32el.sha256sum] = "8d8e0a575a69d1153e1dc1a3d46f3ada3e6640188608341375a4e24e47df1d8a"

require enigma2-bin-4.3.inc
