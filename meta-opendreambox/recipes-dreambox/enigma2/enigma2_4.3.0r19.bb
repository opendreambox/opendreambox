SRC_URI[armv7ahf-neon.md5sum] = "41d65a6b49a1d81184580e4a098d6aa5"
SRC_URI[armv7ahf-neon.sha256sum] = "eb9520b4e1266df0ac94e5d5fedbfd94772b6b0fedfbf69c72dfa5b4640fad0d"
SRC_URI[mips32el.md5sum] = "080bfcf3f73dd43a282fd76baa71f302"
SRC_URI[mips32el.sha256sum] = "b45f8bfdeffdfd0dbddde149500fdeb6ff8e3666b391b91e805d2ece4f01afdf"

require enigma2-bin-4.3.inc
