SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "28a9db786a7ddebf597559215a4d03b8"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "eff81c544d6e1105d495b14b6cd18b2f18c37e93e3f3e7c7f02763db19d64cd9"
SRC_URI[mips32el.md5sum] = "616579b04aa52bdbd6704c4561c0b1e1"
SRC_URI[mips32el.sha256sum] = "6686daf389fb41d6b59f115c7fcee4765946408ed59dfc9cc1e124c6f2a41474"

require enigma2-bin-4.3.inc
