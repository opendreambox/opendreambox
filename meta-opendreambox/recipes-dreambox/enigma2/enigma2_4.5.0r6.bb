SRC_URI[aarch64.md5sum] = "75db6ca3c78b80c01a7a621d6611f71c"
SRC_URI[aarch64.sha256sum] = "1af6b8e805ce768da14df3cbfe15ffeabb18c273478f8d8d01cff8dc76229a35"

require enigma2-bin-4.3.inc
