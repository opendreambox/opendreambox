SRC_URI[aarch64.md5sum] = "989ab7a31c613e95257fa84a44a74b10"
SRC_URI[aarch64.sha256sum] = "3c5273a5c066e9b7dc0b83fd5b66da139a31a533abde8c9ddf897b0e49a6af4a"

SRC_URI += " file://0001-enigma2-environment-fix.patch"

require enigma2-bin-4.3.inc
