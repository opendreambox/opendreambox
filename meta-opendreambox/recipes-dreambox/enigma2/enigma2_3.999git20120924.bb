PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "e86350416f63d13db7a06022e4fcfbdb"
SRC_URI[mips32el.sha256sum] = "da396ad4fc43c0b8e23ad83259912d720fa9773ee90eaec55f64db15649e51f0"
SRC_URI[mips32el-nf.md5sum] = "4345c38131c1b5aa5bb7dc11d279b37e"
SRC_URI[mips32el-nf.sha256sum] = "fb99857910723540c73b819136ed44964313f1bcca69de4fb492a7e50a4045ec"

require enigma2-bin-4.0.inc
