SRC_URI[aarch64.md5sum] = "108b78c0231cfc3e7fc6e8a9771597d6"
SRC_URI[aarch64.sha256sum] = "357d9cfd5c1b75ed96e94e5a4e86a48b46f91bdf39b388ca48e49aefabdbc2c6"

require enigma2-bin-4.3.inc
