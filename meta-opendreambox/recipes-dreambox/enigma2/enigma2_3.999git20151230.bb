PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "0a181f10d4c539d96939a8a712d92dae"
SRC_URI[mips32el.sha256sum] = "55bca8faca4fa634a471603656787eb935a0606435863e373b371f1cad623e06"
SRC_URI[mips32el-nf.md5sum] = "f6cd06eb02356ee2c4135857612ff200"
SRC_URI[mips32el-nf.sha256sum] = "e9a263c480636426d15d76b0fedc8e61a65c343355a137fc2ffc79784fc70844"

require enigma2-bin-4.0.inc
