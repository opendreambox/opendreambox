SRC_URI[mips32el.md5sum] = "0b13df13f101997d01145e30ee9ceb7f"
SRC_URI[mips32el.sha256sum] = "26a5124e9f38413b9b8fb103d2498e3f54a65c74235fa58bc0bc830091890e4d"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "4e716a1c7b98f2cc761fefbb479b9399"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "b7da8728678a959318a194ca65f67ce3fbf2faeff72b63167cf37d9d58c6ed63"

require enigma2-bin-4.3.inc

