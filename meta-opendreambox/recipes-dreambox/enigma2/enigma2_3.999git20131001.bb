PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "f5a2fca4f0a5649ed21c63adf59b1ac5"
SRC_URI[mips32el.sha256sum] = "56403d63a14bd08f522fcc1738ab99739d1cfe83a773c9724b69c7886e98f6ce"
SRC_URI[mips32el-nf.md5sum] = "56cd40c98e816650255be560c4e6ba6c"
SRC_URI[mips32el-nf.sha256sum] = "53de3d00857d1ff9c9da657ce3b35abd38089f8fad3060ba68d4c954bd04adb2"

require enigma2-bin-4.0.inc
