SRC_URI[mips32el.md5sum] = "139723bca81be382a800d3a621d3de3d"
SRC_URI[mips32el.sha256sum] = "5e54e541070acae670b088ce68abfe96db4859fc24a5f27bb289ac0909d20d6f"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "f35f7a44e4298f0c463499b5e9ce1b31"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "90e4e48c48199fdc4e3f4e02acbc6d4fa98bcc2d33a9ff2cc10b5b004267c27e"

require enigma2-bin-4.3.inc
