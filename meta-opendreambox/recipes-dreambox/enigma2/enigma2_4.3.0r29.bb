SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "a69e2ccd6b6fdade032862ec6224013d"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "cd43cc3b5cd40d0f7822225a864d7001ef12e1f991fa375da3c49f833bc8856c"
SRC_URI[mips32el.md5sum] = "82f726ed33ee7246ec39d7fc198cbe6c"
SRC_URI[mips32el.sha256sum] = "d68b069724aa8351806ae685e26bf1ce47a6a0dbc3cf4b1034eddcf8ef550ab4"

require enigma2-bin-4.3.inc
