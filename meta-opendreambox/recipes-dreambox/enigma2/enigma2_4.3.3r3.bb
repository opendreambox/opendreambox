SRC_URI[mips32el.md5sum] = "452f29f863af930f8c80a09807efd2c7"
SRC_URI[mips32el.sha256sum] = "adc4f1bb65dd87b55ef5934a4d1d4f34713987bf25f35ba43f273f47283c4392"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "9f53dac22ad1fe80670347012ffde2ec"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "2762f84ba4f209a51b704e6f4e92e097334dacd00eee7028eae4525ab75ab9ae"

require enigma2-bin-4.3.inc
