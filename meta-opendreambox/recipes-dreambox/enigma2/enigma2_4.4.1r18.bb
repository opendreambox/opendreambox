SRC_URI[aarch64.md5sum] = "c9ca58511c1e7ac9d88ce82814fdb763"
SRC_URI[aarch64.sha256sum] = "0ac39a2e48790744b8cac7ac877fffb1a49c93ed58122b508a97d71e9e7fed92"

require enigma2-bin-4.3.inc
