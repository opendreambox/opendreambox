PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "4b71c1fb02a36d6bdc19699192c0f115"
SRC_URI[mips32el.sha256sum] = "d6ea3610bf1ce9d4bbb84dd61e4478f08005c78b8ee86b4215ea8ce6dc890a3f"
SRC_URI[mips32el-nf.md5sum] = "57c394db0098ee513f700605700a7338"
SRC_URI[mips32el-nf.sha256sum] = "758b868f3bd7f4dc5a3c8c4c13b3b3eb8194ec008b4fe742617d2c22675a33a4"

require enigma2-bin-4.0.inc
