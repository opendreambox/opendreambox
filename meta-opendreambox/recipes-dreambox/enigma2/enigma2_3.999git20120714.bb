PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "168cf6840f9b73c0c7fe34478f6366fe"
SRC_URI[mips32el.sha256sum] = "91ce370f906e576a68bf2ad9ea931b0b6216dbb570cd1c1ba7989f455d6e65b1"
SRC_URI[mips32el-nf.md5sum] = "6c9dbd6b3cf68696b9d894f0507c08ca"
SRC_URI[mips32el-nf.sha256sum] = "c2a0fd2ec56230e5c349290f008499c799d596baa7796aa64145574a009c78c1"

require enigma2-bin-4.0.inc
