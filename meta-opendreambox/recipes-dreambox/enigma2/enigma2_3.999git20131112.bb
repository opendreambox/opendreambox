PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "cc04b7fd8db58e4b4a79b15fd3fca0f6"
SRC_URI[mips32el.sha256sum] = "ebde707f2e9dc4676782bdf600bae73af70480963c5e83f30af697fcc336c173"
SRC_URI[mips32el-nf.md5sum] = "73db06836292df80551d44cafd909879"
SRC_URI[mips32el-nf.sha256sum] = "52a98261c77f0ed260a37dac8d9a9788394427abbdc4db651964b470e9291bf0"

require enigma2-bin-4.0.inc
