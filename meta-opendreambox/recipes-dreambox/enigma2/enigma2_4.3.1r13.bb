SRC_URI[mips32el.md5sum] = "e09fb063a863a032002b8adae0107b15"
SRC_URI[mips32el.sha256sum] = "928400c714e31adf7c5e5138db74029d6c341f4846d2c902012da88f3d6008a5"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "a0f5a8280a49448eebb355848cfddddb"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "cb932ee2cfac897a4a98e72d10169bb654e6cdef1f13ddd199fa00897f6acb93"

require enigma2-bin-4.3.inc
