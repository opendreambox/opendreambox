SRC_URI[aarch64.md5sum] = "2384753a691818cebebffb5b91fd92ec"
SRC_URI[aarch64.sha256sum] = "a19949c6f4e048c8a4bb14d7aa089f1d33eeec9d79dd41a6c74ecd15eb3f0dfd"

inherit opendreambox-precompiled-binary

require enigma2-hbbtv-plugin.inc

