SRC_URI[aarch64.md5sum] = "a0845bf9f62e4d38d39f8f1baddd5157"
SRC_URI[aarch64.sha256sum] = "a3a3fb67ef95a31271ac5363e9fca4840f2e2955d302b87fece1bf53e4efaa6e"

require enigma2-bin-4.3.inc
