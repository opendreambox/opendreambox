PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "c97c66ff466e8556326682fc19a8f2a5"
SRC_URI[mips32el.sha256sum] = "a2810d4505df7a594ffdbd34ea89b877c2ad210329a7648e877ee321b4b91cf9"
SRC_URI[mips32el-nf.md5sum] = "f9d34068ea17ab6e553d689a99fe9922"
SRC_URI[mips32el-nf.sha256sum] = "4c6fcd1116b417d998f7152851052edbce9d0129e926e30ea2496c353b032e0c"

require enigma2-bin-4.0.inc
