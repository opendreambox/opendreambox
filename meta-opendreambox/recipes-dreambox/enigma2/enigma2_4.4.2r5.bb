SRC_URI[aarch64.md5sum] = "4355b1725dccbcc63e07b7a09895e6ec"
SRC_URI[aarch64.sha256sum] = "e097b607ede43631082dbeeefbdddb85f0809c5c980f667cee7421f783df4881"

DEPENDS += " pugixml libwebm"

require enigma2-bin-4.3.inc
