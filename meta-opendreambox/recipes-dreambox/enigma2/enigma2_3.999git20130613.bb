PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "5530cd9d29157893b533b6010da9fa3e" 
SRC_URI[mips32el.sha256sum] = "51d8187c0ac6cf06b6652235b96e486b10dd05c44182d006479d2aada0765d8f"
SRC_URI[mips32el-nf.md5sum] = "2bcbae235f44da6af13796867b4fb52a"
SRC_URI[mips32el-nf.sha256sum] = "3813443b4db14723e1dcc1ae1f23a1a0796b10950fe5364be90ec26460a42655"

require enigma2-bin-4.0.inc
