SRC_URI[mips32el.md5sum] = "5baa3b6fd9a509bdd615e9c491cab0c9"
SRC_URI[mips32el.sha256sum] = "23dd6d0c091b08c411a69c2f0a551619e653f372981693faaf509a606aaf00ad"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "46de8b90e2f340884ed7e4c51a9f1021"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "6e67be9b64932b43c9a54a447643ed7914bd7c8a00dbea2a140c571cadc3dbd3"

require enigma2-bin-4.3.inc
