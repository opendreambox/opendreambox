SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "dffb79623e25113b891ea0653ade4e78"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "f4102944bdb4e3098904e2c59276a5bf2f426ceeb7ee82ffc125388f3d96a952"
SRC_URI[mips32el.md5sum] = "ada884a05a05ac621e4daae90c4c7ea3"
SRC_URI[mips32el.sha256sum] = "4c3c95fb81c164c2ff05f77c908694d553f992031a3649d2a449b99a81043a10"

require enigma2-bin-4.3.inc
