PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "3b56b6cb0c57c85e70bb7b3020195a73"
SRC_URI[mips32el.sha256sum] = "6b218df6ec6c0fe6ae8bbe8ebc48764de1faced70bedac1af0a308bee5f4da53"
SRC_URI[mips32el-nf.md5sum] = "94deeb6c5b031c58644788382a9daa8d"
SRC_URI[mips32el-nf.sha256sum] = "1d88dec2b48d12d0e8b7418682206491219c7d4ff232ca24a7feef7bf1b6ca1d"

require enigma2-bin-4.0.inc
