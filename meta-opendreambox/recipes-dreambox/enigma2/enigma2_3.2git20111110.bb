PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "ab962f344eb49809a2a3cdd9df3cf843"
SRC_URI[mips32el.sha256sum] = "a20d41d08cabadf4d765490d687b6775cd0dbc595917c78fcd07f4b2a01833b9"
SRC_URI[mips32el-nf.md5sum] = "cb0548ecd1baf2d04b064ff7da3e359b"
SRC_URI[mips32el-nf.sha256sum] = "a7f1e2f5a178aea62ab625a8d6e6a52a18162fdaa005605aaf4f416d0e0abfba"

require enigma2-bin-3.2.inc
