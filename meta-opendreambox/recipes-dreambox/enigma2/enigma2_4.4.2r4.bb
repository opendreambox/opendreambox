SRC_URI[aarch64.md5sum] = "2bef871f81cbc1a7fe5745b4f937634d"
SRC_URI[aarch64.sha256sum] = "2ac3fe5d93f2ef6af71001a4942cbb7c6be20d19539b4fc9c08e244976b46f60"

DEPENDS += " pugixml libwebm"

require enigma2-bin-4.3.inc
