PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "9849db589006a6b31f8a86a8c7fe7b96" 
SRC_URI[mips32el.sha256sum] = "f62175679e4013201116883588f47169de73ddac3a6af4c0d56ffb86f9bf36a8"
SRC_URI[mips32el-nf.md5sum] = "2c6c677dec66634f41debaa3171a8386"
SRC_URI[mips32el-nf.sha256sum] = "f62175679e4013201116883588f47169de73ddac3a6af4c0d56ffb86f9bf36a8"

require enigma2-bin-4.0.inc
