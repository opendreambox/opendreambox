SRC_URI[aarch64.md5sum] = "6fe99f61d2d3fe133470e72a250f6be6"
SRC_URI[aarch64.sha256sum] = "10d3add4c76f7bcc49c66181f45f8d48929d834b560e16c59fc39fc4a06c44e5"

require enigma2-bin-4.3.inc
