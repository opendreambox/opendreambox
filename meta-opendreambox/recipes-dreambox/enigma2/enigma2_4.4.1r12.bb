SRC_URI[aarch64.md5sum] = "978bb524b9e8ef2397d352c3e2576470"
SRC_URI[aarch64.sha256sum] = "e72ecfa3e76dfa2ab746403d5a1e8738efe1e7349a81cbd6e6abc989d7f41c43"

require enigma2-bin-4.3.inc
