PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "6bd6042d8b28b585f451bccfafd6ae9d"
SRC_URI[mips32el.sha256sum] = "b34c33672f8a2acff2831ef40f4b4acc9bb9f3877971bfa62799b1be8efc1dd6"
SRC_URI[mips32el-nf.md5sum] = "d85052946bc6ed5887b613ecd1a7f522"
SRC_URI[mips32el-nf.sha256sum] = "4313601ce97a3fe0a5e53f2f966740e25a591b35785348d78f4a174fe9bbb02e"

require enigma2-bin-4.0.inc
