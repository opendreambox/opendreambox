PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "00360eb63093ac31f44c768541026da7"
SRC_URI[mips32el.sha256sum] = "a2e8ed185abc60b27302de3714e1d955d5d09d83cdf9ee0bfe50b804f6f6f6ec"
SRC_URI[mips32el-nf.md5sum] = "c0ba933fa070360df81811f85738c66d"
SRC_URI[mips32el-nf.sha256sum] = "84ff0d2d0327b257b46dd0e6757ed3a6d854ab633187b28588b4a2417fe3a6fb"

require enigma2-bin-4.0.inc
