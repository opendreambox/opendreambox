SRC_URI[mips32el.md5sum] = "729292e96e74976460b7a6a8e7dce920"
SRC_URI[mips32el.sha256sum] = "7541544df56ad1c82465b0065239b7f16a5b22574b4fa9e5d815b04cca2c2868"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "e272ab99e58349ff73121fbbd0dbaf58"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "81f6c195a90b56865ff98095fbb612e5ff7c0e4ac09fdf1383d5ddcfe0d39cbd"

require enigma2-bin-4.3.inc
