SRC_URI[aarch64.md5sum] = "7d016ddfc843a5a05f731ad8d30f1852"
SRC_URI[aarch64.sha256sum] = "54dde8eba0c082f64c89769ce4b2b5b4244125ec59b4fbaa3baa534167900aec"

require enigma2-bin-4.3.inc
