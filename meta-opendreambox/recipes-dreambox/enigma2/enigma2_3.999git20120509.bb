PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "3afbea5376fbfa4b292fbfbeb02f457f"
SRC_URI[mips32el.sha256sum] = "248c9d37e48659c62c0d92241da7947f53c8a2feea3b372678aef3477e2ff63d"
SRC_URI[mips32el-nf.md5sum] = "84431dd88cb5675e3c1ca3c3109c76d8"
SRC_URI[mips32el-nf.sha256sum] = "fc99f90ea63e7feb7bd35469844afc49fa33d6b5ef2875e4e659c0c3b29cb7d8"

require enigma2-bin-4.0.inc
