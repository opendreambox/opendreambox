PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "d93061b0f415e275167c0c36d3c0938d"
SRC_URI[mips32el.sha256sum] = "00dddff416a2ff5815e39b5d68e4df06e9c4f17f6a467e3d295aba3dd24c5983"
SRC_URI[mips32el-nf.md5sum] = "f519a3922c8f142b1f832e57b9493a3c"
SRC_URI[mips32el-nf.sha256sum] = "8630c7c01c9fbdffdb007785b898ff379847b3aff1e6e7ca914618d28ccb37f1"

require enigma2-bin-4.0.inc
