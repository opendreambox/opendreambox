SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "e833add03c429041a5a71f5185898de7"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "323b3f810c93db4fd2d1bcb6e6422b9887c163656596a41b72ae49d9d52e0a91"
SRC_URI[mips32el.md5sum] = "106b8fc53dada2f1320791130a6f21d4"
SRC_URI[mips32el.sha256sum] = "66ca79c6ad44ab23f8b344774639f8c59985e22c8272756a17d80b80e3db1e7a"

require enigma2-bin-4.3.inc
