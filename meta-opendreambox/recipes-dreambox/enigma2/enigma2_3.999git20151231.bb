PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "05e43afe2df7aba3ae9f7df9e194235d"
SRC_URI[mips32el.sha256sum] = "b7ff895ac7c06640e33ff3494b3d658d92f353a9e74986bacbd35ddad2093d45"
SRC_URI[mips32el-nf.md5sum] = "6de773adf14ebb3e77f59c730ab45eb2"
SRC_URI[mips32el-nf.sha256sum] = "60bf379fe36c1179b933362fad3de79f43ae0b0b8c6236769e2d7b651759937d"

require enigma2-bin-4.0.inc
