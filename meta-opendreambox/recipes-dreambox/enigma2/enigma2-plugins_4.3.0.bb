require enigma2-plugins.inc

SRCREV = "${@opendreambox_srcrev('13468d05e4e8872de37d0e5a5ba5ac9579697b60', d)}"

inherit opendreambox-github
