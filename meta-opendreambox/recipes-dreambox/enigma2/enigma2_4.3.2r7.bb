SRC_URI[mips32el.md5sum] = "59f1a35a11e8df2315cbf6b9990e0b64"
SRC_URI[mips32el.sha256sum] = "11716571d0e54864da164c077934ced44b169c6acc158b674cb5aecbbf7e235b"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "6c791205ff650330b2f4020d7c78ad6e"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "4a93f5df655d06cd940be22ca074b215e11cf508498ee01fa91c03e6bd7ec3e6"

require enigma2-bin-4.3.inc
