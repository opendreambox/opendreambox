SRC_URI[aarch64.md5sum] = "05dd77acbb17628cd06f8812c7c90af3"
SRC_URI[aarch64.sha256sum] = "482b8869b9c5c9348d5d9175378e3da2dcd09cecd2e4502090c8c6e681683147"

require enigma2-bin-4.3.inc
