PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "1322ab666aaa3fe8dcdc4d84e936c75f" 
SRC_URI[mips32el.sha256sum] = "6726ff61bf4d80f582652c80003c19da02d34acdddb891b3bd1168d4d3dcf9fd"
SRC_URI[mips32el-nf.md5sum] = "861371f7ae2ce5bc289866318be36c83"
SRC_URI[mips32el-nf.sha256sum] = "a49c5cff72ee376dfd8e0fa5692b9896b679bbf049470b578561188910e8c1b4"

require enigma2-bin-4.0.inc
