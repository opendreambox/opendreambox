SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "93850b0c0e329d53c47744662c4ae9de"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "e1fa6be4805c401c85fc920a8e8a35a6242d7afa1e91e1bfd11a4deac3ac0503"
SRC_URI[mips32el.md5sum] = "5e0eeded97255f9683c70893cd767a82"
SRC_URI[mips32el.sha256sum] = "e1b9961c9f60a6a4a32497c7c67d8d2058d237a4f3ca265f5e9730a78fa8a263"

require enigma2-bin-4.3.inc
