PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "bc394a4cb2fba0c7079da8558bf186ac"
SRC_URI[mips32el.sha256sum] = "69898f480514ed06ab9cd023b67910bbd627d9258e46e561fff0df3be74b3f5a"
SRC_URI[mips32el-nf.md5sum] = "df27a384830d134765b9535777fe460c"
SRC_URI[mips32el-nf.sha256sum] = "9f63e75c64a1397fb31a53dffc4d35b25ea8ee204033eaffd8a266570df2779e"

require enigma2-bin-4.0.inc
