PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "45900f798f117297f4ab8a428b78eb4a"
SRC_URI[mips32el.sha256sum] = "6d89feb5589fd6ae1df9b6c211c9dd10e9bb207599d2c39acfa256406fb91763"
SRC_URI[mips32el-nf.md5sum] = "1a99a10b3a6f99ef90267de0491f9788"
SRC_URI[mips32el-nf.sha256sum] = "2d67139366e4ab271f6bd4778670bcef42959d2935f93b2956b71f3d6a2753f7"

require enigma2-bin-4.0.inc
