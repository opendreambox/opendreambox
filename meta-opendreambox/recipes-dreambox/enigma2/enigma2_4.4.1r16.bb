SRC_URI[aarch64.md5sum] = "3c6f9d56e9a066e96bf0793e663bf347"
SRC_URI[aarch64.sha256sum] = "b7ce79a868084107ca5b47dfe23953f0df1a6986771657e73da1d6e07b10cc57"

require enigma2-bin-4.3.inc
