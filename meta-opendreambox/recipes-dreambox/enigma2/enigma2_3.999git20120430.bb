PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "5a333e39c9390315f34e0c3384295053"
SRC_URI[mips32el.sha256sum] = "14a37a70b3a7d95076fa27efa44cafd8b342953bccda63cea297f7e16e593ecc"
SRC_URI[mips32el-nf.md5sum] = "9d9e7a95c8eb99ae8876766813fc326a"
SRC_URI[mips32el-nf.sha256sum] = "a4cc77365643d082fd2da0fada2e521f9b5d7b7d79a474730a55439b6ad76ea9"

require enigma2-bin-4.0.inc
