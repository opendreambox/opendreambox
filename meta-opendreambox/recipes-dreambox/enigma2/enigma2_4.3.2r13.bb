SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "0ca30855c946aaaad1fb83b6f85e9d82"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "74eb66bd4a8e5c9b397db661789a56f59c6e529d4ccfc720108153a66cc2bb82"
SRC_URI[mips32el.md5sum] = "f2b50713e33e35f715d3be5e5ea78bdb"
SRC_URI[mips32el.sha256sum] = "066641ec70baf9f4a3076e5a28d8b83ca847e36341ce17dcf2fe7534b75ecd3d"

require enigma2-bin-4.3.inc
