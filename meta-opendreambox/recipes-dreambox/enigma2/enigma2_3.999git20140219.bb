PR = "${INC_PR}.1"

SRC_URI[mips32el.md5sum] = "e1010ca2c45d70b922e12018f3e0f843"
SRC_URI[mips32el.sha256sum] = "b3c57fc66b386c2b71c31ab79f2e063a73ca0e7b7cef63c9124de52050d14737"
SRC_URI[mips32el-nf.md5sum] = "908b3549f9a57c0ae53a37695681a8be"
SRC_URI[mips32el-nf.sha256sum] = "9b85483d5909cb5dcdba822c1374b9970381497ed75c09419db60f13706cad4d"

require enigma2-bin-4.0.inc
