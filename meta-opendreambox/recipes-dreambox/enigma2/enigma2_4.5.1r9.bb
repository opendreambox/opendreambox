SRC_URI[aarch64.md5sum] = "f239e164d8df2b7531d63b468c9b3224"
SRC_URI[aarch64.sha256sum] = "7e5407979a1b585c0f386bdfa1d18a45c2a0ca13d6c1cbfddc2d562bd5f154ad"

require enigma2-bin-4.3.inc
