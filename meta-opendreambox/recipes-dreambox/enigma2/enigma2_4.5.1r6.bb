SRC_URI[aarch64.md5sum] = "523e0803c4d1f27a308f8e36a233a609"
SRC_URI[aarch64.sha256sum] = "92250b30376a5da579d7bec0175e39960c77dac0ca42de9c6ab0eb716d66dfc8"

require enigma2-bin-4.3.inc
