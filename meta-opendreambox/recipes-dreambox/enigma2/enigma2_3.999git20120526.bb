PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "1393bb352ef496dc6d0c49dd382ad2bf"
SRC_URI[mips32el.sha256sum] = "9fec87e7ce2c11d421626fa351a1b7e822dc9dd80f6beebcb5beba2d5f215f3b"
SRC_URI[mips32el-nf.md5sum] = "82021dfef61c862589af7665e10be1c8"
SRC_URI[mips32el-nf.sha256sum] = "6bf2effd8a7dadba810656c0c3944a05cb8c7c55312e313235b352753c0b3d98"

require enigma2-bin-4.0.inc
