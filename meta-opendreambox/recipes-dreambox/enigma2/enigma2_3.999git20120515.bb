PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "724eb378cb92a7c31c000d8dde477c65"
SRC_URI[mips32el.sha256sum] = "a577a8338ebd426451e87715670c77539efaf68ef64e9f34a77b6718f63b36c3"
SRC_URI[mips32el-nf.md5sum] = "95a775007619a9ad2b7d7dc75ff6c07d"
SRC_URI[mips32el-nf.sha256sum] = "18214af0b2a181ca242b3ca9bcd3d7919bb6bdc19f47dec45de2a85646cf5524"

require enigma2-bin-4.0.inc
