
SRC_URI[mips32el.md5sum] = "6a4196cfdf2dec78f0f0bb2c11b645e3"
SRC_URI[mips32el.sha256sum] = "6bace7335a6b3c201f127498b8b50fc0ce7c47d6c88f68837b3dedfc87ffae36"
SRC_URI[mips32el-nf.md5sum] = "734ac0dd78e054924492611481a29164"
SRC_URI[mips32el-nf.sha256sum] = "8f2ffd43c99dbcc658382da871a276ee3ce4eded9a28518fce7b13ba06022753"

require enigma2-hbbtv-plugin-bin.inc
