SRC_URI[aarch64.md5sum] = "5a405783764a98b9418460820a564808"
SRC_URI[aarch64.sha256sum] = "513b5ef1a0d1b61b6c8d63e9903620bff053c26fd2bc423a168f246c98a2ad31"

require enigma2-bin-4.3.inc
