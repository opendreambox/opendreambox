SRC_URI[aarch64.md5sum] = "ac424d75fc98bf134ba347c1d068e26a"
SRC_URI[aarch64.sha256sum] = "d0495e47b8cd4357c49b61751d307312ed0a6922b6671e601ba45df8794a6d19"

require enigma2-bin-4.3.inc
