SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "4f29e757de53e1560f9ac636df14628c"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "86f9d96fe7c9882d2e104adad942a8f1a4f4ae3c0fba2bd21a92f2a7ea0b26a2"
SRC_URI[mips32el.md5sum] = "605494d897c6956c484acbd511759182"
SRC_URI[mips32el.sha256sum] = "4e72f74dfb60056a6ea97c95d79beee60adc8e8ba0ee3e3bb24bb4aa3ebac87d"

require enigma2-bin-4.3.inc
