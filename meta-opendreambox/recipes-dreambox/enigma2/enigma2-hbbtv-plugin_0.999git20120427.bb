
SRC_URI[mips32el.md5sum] = "9079cc27ea7df2fc8f14d51796dfde51"
SRC_URI[mips32el.sha256sum] = "e0401c2e4f90526267535ee5e62b54de090878aec9f38a78f1c8d537685217e9"
SRC_URI[mips32el-nf.md5sum] = "d44a5c1a93b1644cae6e51b44909a673"
SRC_URI[mips32el-nf.sha256sum] = "15cc50542150e36916932f460f85c5d3b855b06b74a3f372cdbb3c166617fb5d"

require enigma2-hbbtv-plugin-bin.inc
