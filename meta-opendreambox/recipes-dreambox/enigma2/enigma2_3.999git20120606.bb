PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "6e63074b55ec14a81d5e202abf93b9da"
SRC_URI[mips32el.sha256sum] = "da190cdda60d71575958a3c5b06d1bbf5d5832cb0f6d8cc892c78cf96f1713e9"
SRC_URI[mips32el-nf.md5sum] = "68eb485b4bda8454494521981874f870"
SRC_URI[mips32el-nf.sha256sum] = "fd836fae0a3d76f6b82af34f78f08c4f5e7bb53242f99db98d5a8b34f4bcb0c6"

require enigma2-bin-4.0.inc
