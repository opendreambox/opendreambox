SRC_URI[aarch64.md5sum] = "0747afb8507953c8b96788f8c598f5da"
SRC_URI[aarch64.sha256sum] = "be1d362cbe0a3b788905ca3782cfadfb391b2a2b9ed272c059d62013d1be0790"

require enigma2-bin-4.3.inc
