SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "09841941fd2e9431ca35e06357611e65"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "302eacca775737d4758dcd33004dd952d9f780ee2c9cd085fed19e303f6d3928"
SRC_URI[mips32el.md5sum] = "0fb66993a5ee1559c24424b11fe0faca"
SRC_URI[mips32el.sha256sum] = "7956c508d2475b8d5ad825186b344c20c584f078bd52c468b3c72e6fbf0815f6"

inherit opendreambox-precompiled-binary

require enigma2-hbbtv-plugin.inc
