SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "40063810f3fad59719dcc605d009bfd1"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "38e1011fadfda6d680912f3ad5177674be65e51b945aab016a0e8269b8307ce9"
SRC_URI[mips32el.md5sum] = "100bb084fc61f24d6af5c3383362a809"
SRC_URI[mips32el.sha256sum] = "2a3c1c1be249bf24cc8be5e2e4c73d3c5f546d4ec658e6c68b66cdc5a6ebb10f"

require enigma2-bin-4.3.inc
