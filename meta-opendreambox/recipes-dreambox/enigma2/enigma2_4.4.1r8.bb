SRC_URI[aarch64.md5sum] = "63bf9218702442b9cc2052cac196eb46"
SRC_URI[aarch64.sha256sum] = "986bc3d8bd87172a2c387e23e6e43a204637b90fecba34a69586ce0dcca07d09"

require enigma2-bin-4.3.inc
