SRC_URI[aarch64.md5sum] = "cc6d5c4b0963478dea286a0245d6ede5"
SRC_URI[aarch64.sha256sum] = "0c9bf6d8f2ff54111b98d6164a3e04a14b0397167ad726bc3138283844b0489e"

require enigma2-bin-4.3.inc
