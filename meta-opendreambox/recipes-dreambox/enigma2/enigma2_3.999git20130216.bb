PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "e9caefd820c5f0105fa7cb3b9a0b539a"
SRC_URI[mips32el.sha256sum] = "2cc0f18079a8ca9b6245a33858f57fa4bde8a28efeb69725b88f2470ff89c70b"
SRC_URI[mips32el-nf.md5sum] = "959167ad697a67e9b6ef346003d60b90"
SRC_URI[mips32el-nf.sha256sum] = "b10b3b6679da60efb32acb69c429358ac6b9c492d6d7eeb67bc09e5391efd922"

require enigma2-bin-4.0.inc
