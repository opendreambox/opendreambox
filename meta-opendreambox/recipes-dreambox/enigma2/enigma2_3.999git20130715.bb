PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "7e32075603f43481b5e659988da97548"
SRC_URI[mips32el.sha256sum] = "7e1b74e237c7f10cac4295c7fe9274ff96d7616d06362d0c3b1ab57513edbfee"
SRC_URI[mips32el-nf.md5sum] = "88b0a3fd153e1c15ceb4b8758f39fe34"
SRC_URI[mips32el-nf.sha256sum] = "0570ac7a6b528bf0c517b83a6a63681934ecff1179caa5cdb9fe034c33f03752"

require enigma2-bin-4.0.inc
