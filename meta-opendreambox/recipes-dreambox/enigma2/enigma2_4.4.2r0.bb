SRC_URI[aarch64.md5sum] = "6d9a484b553a5906c9350b1c56edc98c"
SRC_URI[aarch64.sha256sum] = "0df50579df858e527512c5cbc6bf5042eec7653cff2f0231d875825a681f1441"

DEPENDS += " pugixml"

require enigma2-bin-4.3.inc
