PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "b67ab5e5fec1670a042c3c064d07e0a4"
SRC_URI[mips32el.sha256sum] = "c90d9ea252f3e139f77250af516b40f9f08cbcdad24dca648b2eb0e61ce336f0"
SRC_URI[mips32el-nf.md5sum] = "e5119c4751d3d485edbc00a5fb528498"
SRC_URI[mips32el-nf.sha256sum] = "a9ab6135444374975231f081648fbe4e08907ef99ae6c0607dead1420734a232"

require enigma2-bin-4.0.inc
