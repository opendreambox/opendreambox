PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "45a2b313ffafc1da0e6e8e7246572fa0"
SRC_URI[mips32el.sha256sum] = "b4c5189d7b0cd943aa3d039adc5663f80e9cc033eb78cee959d19ef61d582027"
SRC_URI[mips32el-nf.md5sum] = "36c36e62af69558bcadccf58da09b5cb"
SRC_URI[mips32el-nf.sha256sum] = "b4c5189d7b0cd943aa3d039adc5663f80e9cc033eb78cee959d19ef61d582027"

require enigma2-bin-4.0.inc
