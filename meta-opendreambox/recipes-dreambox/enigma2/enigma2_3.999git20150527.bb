PR = "${INC_PR}.0"

SRC_URI[mips32el.md5sum] = "566db691025c7e28612cad6efee83ac5"
SRC_URI[mips32el.sha256sum] = "c3f25a75f75dc3940b39b54e59c8675a015f98cbd6d668618c988e890d37621e"
SRC_URI[mips32el-nf.md5sum] = "96281b2bfb4604f3abd052d93c2da8f1"
SRC_URI[mips32el-nf.sha256sum] = "1adfabf2a510864e7594eb37f5054b7b80bb9301eccb70165ff4c3cda580b1eb"

require enigma2-bin-4.0.inc
