CURRENT_FW = "central-two-noreset-200423-1.12.hex"

include nrf52-firmware.inc

COMPATIBLE_MACHINE = "^(dreamtwo)$"
