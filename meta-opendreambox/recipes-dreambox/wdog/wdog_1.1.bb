SUMMARY = "Dreambox watchdog to automatically restart binaries"

SRC_URI[mips32el.md5sum] = "37713986ab051cd98772a4637247527e"
SRC_URI[mips32el.sha256sum] = "7e4c387f4989ba220b072a5bf4c22bb044ca7b6410327b8474aef94f86a177c2"

inherit opendreambox-precompiled-binary
