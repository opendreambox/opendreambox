require enigma2-plugins.inc

SRCREV = "${@opendreambox_srcrev('ca0e981b22513137279aa65239944fd1bd52c45f', d)}"

inherit opendreambox-github
