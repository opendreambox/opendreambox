require enigma2-plugins.inc

SRCREV = "${@opendreambox_srcrev('fca9f5f50b2f04d2063ad58c26fca4b5f818d73a', d)}"

inherit opendreambox-github

GITHUB_BRANCH = "4.3"
