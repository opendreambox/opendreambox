
SRC_URI[mips32el-nf.md5sum] = "61acb8936067078673dd9f51ad473f0b"
SRC_URI[mips32el-nf.sha256sum] = "60d8ec745364055bf5af57d037726d69a115938ef2d383ed33089d54e973532b"
SRC_URI[mips32el.md5sum] = "2aaf56dcc1b2a02d43738b7b1b9c1b29"
SRC_URI[mips32el.sha256sum] = "c0eb901db36d4451fa8432ab138260d25ef02d46bde4680ab7ab4da5fac4fa0f"

require dbttcd-bin.inc
