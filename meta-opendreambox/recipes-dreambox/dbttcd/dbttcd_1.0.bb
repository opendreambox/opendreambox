
SRC_URI[mips32el-nf.md5sum] = "bd15ef0a4f1d74e842a1408a1731eb5f"
SRC_URI[mips32el-nf.sha256sum] = "abf64903741f0b761065a62d6178450b839d63ce07008bbd3301d3667319a4db"
SRC_URI[mips32el.md5sum] = "a468b6db7fcb2ec2e8cef648ac01a951"
SRC_URI[mips32el.sha256sum] = "671b67f4e90331c4a032bddc80c60ad45e4821d9b879663662be124a96d82877"

require dbttcd-bin.inc
