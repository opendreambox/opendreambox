
SRC_URI[mips32el-nf.md5sum] = "06d6260ba24d4239803226680d35c195"
SRC_URI[mips32el-nf.sha256sum] = "5937986ce94ba63a326b4e0d496f5ebc880f044c25afa95c87e37aedd5b46863"
SRC_URI[mips32el.md5sum] = "578d99fd1a212086a53e767a6824d326"
SRC_URI[mips32el.sha256sum] = "adce632b09d33cafc645f993685b9499c28333c2781ccc700f6d39962e6b6121"

require dbttcd-bin.inc
