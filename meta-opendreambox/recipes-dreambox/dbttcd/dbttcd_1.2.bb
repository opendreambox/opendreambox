
SRC_URI[mips32el-nf.md5sum] = "eb34fa4c282c2cf334c93660c828a0ed"
SRC_URI[mips32el-nf.sha256sum] = "86c8ce6555fd51787f17346bbf2941bb9676d63fd32f61faf3d2949611560b7f"
SRC_URI[mips32el.md5sum] = "f4ef9954cecbde40cb972ad84c337713"
SRC_URI[mips32el.sha256sum] = "b4186ea7a8bd8e2eca057544a35983b9b1ef3d823b737606b1a1bc8db8103161"

require dbttcd-bin.inc
