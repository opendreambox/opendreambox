
SRC_URI[mips32el-nf.md5sum] = "3664079874ff5acf7559d4e089943a47"
SRC_URI[mips32el-nf.sha256sum] = "a1eb3440fa5c1f5e2da01b05579755d40fbc73781d0d1a8e3964a3b9e38128f6"
SRC_URI[mips32el.md5sum] = "de312eef68675e888f5f287f583a84d4"
SRC_URI[mips32el.sha256sum] = "fe9eae63e90173a8c315f1fd622cabef2a858afc815ced6c2e112b4fa016b13e"

require dbttcd-bin.inc
