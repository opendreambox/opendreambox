
SRC_URI[mips32el-nf.md5sum] = "d81a8110bcd653b63cb690f9ad6f3421"
SRC_URI[mips32el-nf.sha256sum] = "c1883ff7aeab16479d9bb1fe952340472d175b7e936e4acdb279d4fda63c7f03"
SRC_URI[mips32el.md5sum] = "3ed6976f2f63fb9a3950d5ac5c4492f9"
SRC_URI[mips32el.sha256sum] = "e191d10957da375ad947a69eefe42f1501f6b4b170d19baa15c5dffa4fbbd21c"

require dbttcd-bin.inc
