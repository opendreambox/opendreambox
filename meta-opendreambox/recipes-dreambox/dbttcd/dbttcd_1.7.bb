SRC_URI[mips32el.md5sum] = "e8c04bd5b0e446f874a52156955a78c0"
SRC_URI[mips32el.sha256sum] = "635280a24ffaee524b0acadaa97bdeee8112471327d88f278c99203193910c56"

require dbttcd-bin.inc
