
SRC_URI[mips32el-nf.md5sum] = "31914a1011b9472808bc2f1b4ced1079"
SRC_URI[mips32el-nf.sha256sum] = "1bacd7891774dbe9b33893262e4a1b1d605f3883f9ccdd686441dcc1610cea38"
SRC_URI[mips32el.md5sum] = "39828ccf9983e1d507a6a660e274b4e7"
SRC_URI[mips32el.sha256sum] = "6d87aee18a5c75d8142d73e18ff2b9d4ee77c59af6e419b9bfd13c15c0907744"

require dbttcd-bin.inc
