IMAGE_PKGTYPE = "ipk"

require dreambox-image.inc
