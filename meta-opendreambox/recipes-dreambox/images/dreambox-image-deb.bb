IMAGE_PKGTYPE = "deb"

require dreambox-image.inc
