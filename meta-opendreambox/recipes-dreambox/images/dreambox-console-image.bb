IMAGE_PKGTYPE = "deb"

require dreambox-console-image.inc
