SRC_URI += "file://0001-dtc-Add-support-for-named-integer-constants.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
