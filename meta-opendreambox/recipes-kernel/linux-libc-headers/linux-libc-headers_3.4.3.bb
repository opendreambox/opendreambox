require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "d13125cf34b340e20dd4e54ca88c3b35"
SRC_URI[sha256sum] = "0b01ddf6f826e4adf198fb00f7917e32f3c88545cef51bdea219206db2a9e020"
