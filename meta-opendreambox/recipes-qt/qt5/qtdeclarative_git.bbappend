require qt5-split-packages.inc
