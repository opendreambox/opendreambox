require qt5-split-packages.inc

SRC_URI += "file://0001-Map-additional-keys-for-dreambox-RCU.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/qt5base:"
