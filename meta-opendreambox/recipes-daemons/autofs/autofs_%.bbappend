SRC_URI += "file://0001-autofs-5.1.0-link-autofs.a-into-executable-only.patch"

PARALLEL_MAKEINST = ""

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
