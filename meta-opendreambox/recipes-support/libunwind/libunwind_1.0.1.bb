PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "993e47cca7315e22239c3e0d987e94e0"
SRC_URI[archive.sha256sum] = "aa95fd184c0b90d95891c2f3bac2c7df708ff016d2a6ee8b2eabb769f864101f"

require libunwind.inc
