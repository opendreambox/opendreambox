PR .= "-dream1"

CFLAGS += "-DSQLITE_ENABLE_COLUMN_METADATA"
