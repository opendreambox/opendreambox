PRINC := "${@int(PRINC) + 1}"

CFLAGS += "-DSQLITE_ENABLE_COLUMN_METADATA"
