CFLAGS += "-DSQLITE_ENABLE_COLUMN_METADATA"
