SRC_URI += "git://${LOCAL_GIT_PATH};protocol=file"

inherit git-project
