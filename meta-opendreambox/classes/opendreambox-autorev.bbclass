#
# opendreambox-autorev.bbclass
#
# Sets SRCREVs for selected git recipes to ${AUTOREV}.
#
# Usage: INHERIT += "opendreambox-autorev"
#
# This class doesn't have any code. It uses magic.
#
