require dreamliveserver.inc

SRC_URI[mips32el.md5sum] = "5e3318a44554f9281eb139d893b6fff7"
SRC_URI[mips32el.sha256sum] = "dc8fe8e5ccf30a793622ed71521b999549159ebfba716a8c5d26f2138a27cc5c"
SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "89f2f246027466640861bc81b44783bb"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "406748afca8d7d85aca31a26055815b509d4b9ae00b2e88c8a1d804599d504a2"

inherit opendreambox-precompiled-binary

