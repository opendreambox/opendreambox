LICENSE = "LGPLv2.1+"
PR .= "-dream2"

EXTRA_OECONF += "--disable-gpl --disable-nonfree --disable-version3 --disable-x11grab"
