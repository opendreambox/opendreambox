LICENSE = "LGPLv2.1+"

EXTRA_OECONF += "--disable-gpl --disable-nonfree --disable-version3"

PACKAGECONFIG ?= "bzip2"
PV = "9.8"
