PACKAGES =+ "${PN}enc"
FILES_${PN}enc = "${libdir}/libvorbisenc.so.*"
