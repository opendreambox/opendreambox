SUMMARY = "C++ parsing library for Service Information (SI) in DVB systems"
AUTHOR = "Andreas Oberritter"
SECTION = "libs/multimedia"
LICENSE = "LGPLv2.1"
LIC_FILES_CHKSUM = "file://COPYING;md5=a6f89e2100d9b6cdffcea4f398e37343"
PR = "r0"
OPENDREAMBOX_PROJECT = "obi/libdvbsi++"
SRCREV = "f3c5e6c83734e0e86fdb8329339561ab600634a8"

inherit autotools pkgconfig opendreambox-git
