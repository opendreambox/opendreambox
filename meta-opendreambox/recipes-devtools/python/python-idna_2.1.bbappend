FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-fix-check_hyphen_ok-for-youtube.patch \
"

