SUMMARY = "Attributes Without Boilerplate"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d4ab25949a73fe7d4fdee93bcbdbf8ff"

SRC_URI[md5sum] = "442b73d049af046ced010671b7bfd0e9"
SRC_URI[sha256sum] = "136f2ec0f94ec77ff2990830feee965d608cab1e8922370e3abdded383d52001"

inherit pypi setuptools
