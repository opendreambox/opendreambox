LIC_FILES_CHKSUM = "file://README.rst;md5=5b5fc59487c805c8329067d134f0ba4e \
                    file://NOTICE;md5=78f5bacf7f1c81c3c798887c9e94d745 \
                    file://LICENSE;md5=c858703330162aa799141655a10fe120"
SRCREV = "v${PV}"

require python-requests.inc
