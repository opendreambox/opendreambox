LIC_FILES_CHKSUM = "file://README.rst;md5=460faf82bca0c10d716b8682712dba42 \
                    file://NOTICE;md5=0e347b1a70df2b1c2ee9f02724853021 \
                    file://LICENSE;md5=d9bb3515869c0f426cb8441c899ae7f5"
SRCREV = "v${PV}"

require python-requests.inc
