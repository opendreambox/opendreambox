PR .= "-dream1"

SRC_URI_virtclass-native += "file://01_gnulib_eglibc2_16.diff"

FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"
