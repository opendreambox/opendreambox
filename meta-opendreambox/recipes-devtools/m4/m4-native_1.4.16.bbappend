PR .= "-dream1"

SRC_URI += "file://m4-1.4.16-no-gets.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"
