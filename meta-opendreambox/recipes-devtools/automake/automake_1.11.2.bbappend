PR .= "-dream1"

SRC_URI += "file://docs-avoid-failures-with-development-version-of-Texi.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"
