TOOLS = "adb fastboot adbd"

TOOLS_class-native = "fastboot"
TOOLS_class-nativesdk = "fastboot"