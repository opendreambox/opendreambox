require recipes-graphics/libv3ddriver/libv3ddriver.inc

SRC_URI[dm7080.md5sum] = "07828fa72251de16d30a97112bd1efba"
SRC_URI[dm7080.sha256sum] = "fc5371ed756fe041042bf109d8ef8a5214e2b43e02fffb59f36a86456bcfe636"

inherit opendreambox-precompiled-binary
