require libvc5dream.inc

SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "2b21eb69b2ca53e7fcbb5ef34c702d1b"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "8a9961cb4238854ccc9a04c9c7744679058a696f4745ae5d88079b28b572cd37"
SRC_URI[mips32el.md5sum] = "440d5965dbacc36911912e88d914d421"
SRC_URI[mips32el.sha256sum] = "d2daab6ba19e182dac9f6a162ad0bb5110170e9024ddddefdebe6cd787d220ed"

inherit opendreambox-precompiled-binary
