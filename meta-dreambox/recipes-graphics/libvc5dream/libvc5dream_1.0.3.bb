require libvc5dream.inc

SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "d9b75d8ffd1e69d91d1f33a201eb240b"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "f30c950320cb772643c95077cd30840fa804e03d8b94a9ab2c5f5b597fdbedfd"
SRC_URI[mips32el.md5sum] = "f9648de67b7144ecce1271a1827921af"
SRC_URI[mips32el.sha256sum] = "d8cf13685e216c8b11f4d519098bf2a7023ffcac4bca1d43b64db38da2adf0d7"

inherit opendreambox-precompiled-binary
