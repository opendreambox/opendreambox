require libvc5dream.inc

SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "c434228bec34d328e5438cdcfae988bd"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "b35f496e65a65ab797029898a309e732f05e197a892357ae92704e97e772cde0"

inherit opendreambox-precompiled-binary
