require libvc5dream.inc

SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "8d3411ad487e7324d79108ba5ab15be3"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "d4a44aae3bf7d355a79fe5f22e477f50b6b4cc5d78e18aeba7e8c12cde5ba66f"
SRC_URI[mips32el.md5sum] = "33649920a5b8ae9853f0e34afb727aa2"
SRC_URI[mips32el.sha256sum] = "69e4ca65689bc8e75f894872e79171fda52a2dea08a709affa7ce4b42c142928"

inherit opendreambox-precompiled-binary
