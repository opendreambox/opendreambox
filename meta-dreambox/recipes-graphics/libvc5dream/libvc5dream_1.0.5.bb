require libvc5dream.inc

SRC_URI[cortexa15hf-neon-vfpv4.md5sum] = "a2cad3686f4f066587f1ee1ad33b3731"
SRC_URI[cortexa15hf-neon-vfpv4.sha256sum] = "f0556a06a7c2b0f77a84007717bb4586abe989356af06b76ab7b38c3873c7e1f"
SRC_URI[mips32el.md5sum] = "fc02af3cb7e6c602da9a6d01d32aba44"
SRC_URI[mips32el.sha256sum] = "a25b5509379f1c5cc440a62d9cfa886eef113d9f85a0067846943fa8b5439c38"

inherit opendreambox-precompiled-binary
