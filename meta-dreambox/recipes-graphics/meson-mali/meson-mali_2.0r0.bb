SRC_URI[aarch64.md5sum] = "3b76ee3bd02b2d7c789e9927c00c4006"
SRC_URI[aarch64.sha256sum] = "adb65288f3973476f741b46283520f622b2eb58489f720dcffb46c0d269361e0"

inherit opendreambox-precompiled-binary

require meson-mali.inc
