SRC_URI[all.md5sum] = "15b4bf415daf5aa3fbbe46fe904dd1a2"
SRC_URI[all.sha256sum] = "2372e80453d328400e9ac973670fc508d8343db0eccf7478fa51d44e43fc0f41"

inherit opendreambox-precompiled-binary

require bcmdhd-firmware.inc
