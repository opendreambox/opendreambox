require dreambox-bootlogo.inc

SRC_URI[dm500hd.md5sum] = "ec13a82fe3dbdcad35638a21e038ddc1"
SRC_URI[dm500hd.sha256sum] = "937bb3eee0e681c75ad380699351a65b68251321f25f03336e9cc9bb2de626ae"

COMPATIBLE_MACHINE = "^(dm500hdv2)$"
