require dreambox-bootlogo.inc

SRC_URI[dm800se.md5sum] = "3cb528ec4dba92ce15c11a7c07bb3e10"
SRC_URI[dm800se.sha256sum] = "43bb52542aef2fbed90ef9ecea993e73a1b482a8d38e2f3f412882359d67448f"

COMPATIBLE_MACHINE = "^(dm800sev2)$"
