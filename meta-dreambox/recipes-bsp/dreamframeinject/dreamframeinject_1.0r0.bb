SRC_URI[dreamone.md5sum] = "c5c38db76320c7633dfa180e24e99173"
SRC_URI[dreamone.sha256sum] = "c41e0783c65fdacdbc5a4c09942ac496388ada718139f57d7a6a840415542ba2"

inherit opendreambox-precompiled-binary

require dreamframeinject.inc
