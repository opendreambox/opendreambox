SRC_URI[dreamone.md5sum] = "c56c8b4fdfbc14eaff9453571661cc3d"
SRC_URI[dreamone.sha256sum] = "94acf8b933f4bd5c0808678f65b9db7d03b4a2cc0b992e4ea695a78621973edd"

require dreambox-dvb-modules.inc
