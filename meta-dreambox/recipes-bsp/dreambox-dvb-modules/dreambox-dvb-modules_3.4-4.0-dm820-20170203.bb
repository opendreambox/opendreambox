require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "7385d7822323c98f08d740ac89cbeff4"
SRC_URI[dm820.sha256sum] = "82ffac6cf404061c6378345114b360ca5b615a7b759bdfc87861a55bbcf730b6"
