require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm900.md5sum] = "f2d7e1c044f750fb980ea4f2f9f48dc0"
SRC_URI[dm900.sha256sum] = "ca9da93c77a985a0776b44681c4547bbaf3fc9352a5919fd2e28a6be0ec67d8a"

COMPATIBLE_MACHINE = "^(dm900)$"
