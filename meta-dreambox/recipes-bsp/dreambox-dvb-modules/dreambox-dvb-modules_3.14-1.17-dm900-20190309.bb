SRC_URI[dm900.md5sum] = "85b346c0d41e5f128ba734202cd05e5a"
SRC_URI[dm900.sha256sum] = "fa0aa8005cf8ec1ed4fa34e15ccef1b81eb09c10188281a4a837296d8c9a6870"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
