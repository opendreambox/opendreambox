require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "372657cac34d98df3581407c93b87074"
SRC_URI[dm820.sha256sum] = "08caffa17667c0c340465b93265d888d17bccb673ad01d3b32fef663f6512852"

COMPATIBLE_MACHINE = "^(dm820)$"
