SRC_URI[dm920.md5sum] = "58d3337bb1f784b9ab6b645c5e2be258"
SRC_URI[dm920.sha256sum] = "f337e6043b14e055ac3f08424a848300100424f3d2ebadb3446519727d32611c"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
