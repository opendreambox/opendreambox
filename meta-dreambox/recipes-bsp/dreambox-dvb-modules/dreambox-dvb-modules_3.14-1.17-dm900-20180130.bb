SRC_URI[dm900.md5sum] = "ba3bb3155fe47bc60038bf91170bacab"
SRC_URI[dm900.sha256sum] = "45cc8dae645f49eb11ebd3f29664f0c3151d8ea3a08fae55dc35759faced276e"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
