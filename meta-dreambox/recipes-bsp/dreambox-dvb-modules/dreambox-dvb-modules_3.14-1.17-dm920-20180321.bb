SRC_URI[dm920.md5sum] = "7a4ddc9904c65ce1068aac0484f4b7d5"
SRC_URI[dm920.sha256sum] = "e94b92b22bace98dfc67ee7e162905ff7465dc43c201b4e6745581521f6a7c75"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
