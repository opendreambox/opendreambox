require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "1c9b04d0f49718d6968d94688ad4da55"
SRC_URI[dm820.sha256sum] = "4f3e913752f29201e405ee20bc1be0851de0293801c5c68438930f5ba365190e"

COMPATIBLE_MACHINE = "^(dm820)$"
