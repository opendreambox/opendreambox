require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "7d9f918517f579b251e724a1ec00c446"
SRC_URI[dm820.sha256sum] = "868cdad79432f5407fb50952ec6795d68c3bfccb8cf88784754f3ef186520562"

COMPATIBLE_MACHINE = "^(dm820)$"
