require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm520.md5sum] = "299f53d94755feabaee92713101d9c1f"
SRC_URI[dm520.sha256sum] = "bc5245562638b24d63b81d2df6978826b8aafefa42e220856bc3452defbea815"
