require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm520.md5sum] = "ca8bfaf637b3cfaf1365cebca92bb6d9"
SRC_URI[dm520.sha256sum] = "e4304e6ce9348ff59d30393a360e945018cf6f75f4032a2b41096e7011ca5f11"

COMPATIBLE_MACHINE = "^(dm520)$"
