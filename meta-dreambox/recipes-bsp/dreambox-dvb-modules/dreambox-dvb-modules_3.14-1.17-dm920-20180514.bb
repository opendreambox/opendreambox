SRC_URI[dm920.md5sum] = "ffeab80b6b52a16a38662a771b474bf8"
SRC_URI[dm920.sha256sum] = "3105ac19caf22657018b4cd7405364ed7c45d4147d6318f4a70abc8f69dd7f90"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
