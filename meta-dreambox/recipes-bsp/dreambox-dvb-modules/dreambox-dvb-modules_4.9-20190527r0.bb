SRC_URI[dreamone.md5sum] = "f3ad75ce6267aca24b9d6f82d67fa598"
SRC_URI[dreamone.sha256sum] = "f4f75c7f8d0cc19a491a08147801d585823637287d0886e9c6b99b6b59e2ac12"

require dreambox-dvb-modules.inc
