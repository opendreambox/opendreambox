require dreambox-dvb-modules.inc

SRC_URI[modules.md5sum] = "412b5faae867f8d94608d6ea3657bf45"
SRC_URI[modules.sha256sum] = "74c85bf637793c656a745685d1cfc091b12790d636b4d5ace7d71568d1cb0c4a"

COMPATIBLE_MACHINE = "^(dm7080)$"
