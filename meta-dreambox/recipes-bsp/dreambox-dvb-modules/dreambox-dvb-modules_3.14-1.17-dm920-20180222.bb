SRC_URI[dm920.md5sum] = "c62048cdd9b59871241ab747ca588376"
SRC_URI[dm920.sha256sum] = "b21df39f620834299246cd85a371316af5e5aaddd615170e82bc8f4419435dfd"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
