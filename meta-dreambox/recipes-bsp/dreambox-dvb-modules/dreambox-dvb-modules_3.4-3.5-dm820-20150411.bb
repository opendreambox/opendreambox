require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "b8673d3c49f84249003d5fdb117a2293"
SRC_URI[dm820.sha256sum] = "ed828e36be98a2c4df9e08d82691465dc204f3d44635d6e46c8d676822638afc"

COMPATIBLE_MACHINE = "^(dm820)$"
