require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm520.md5sum] = "0af18ffad8f25ed9adbf143c55847c44"
SRC_URI[dm520.sha256sum] = "f1b807f210a16a516dfe0a86c9ddfaae46cd269944ad938455dab1b410dd6a1f"
