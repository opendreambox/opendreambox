require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "bc27665a498885ce5a8a646ceef9f1c5"
SRC_URI[dm820.sha256sum] = "fb64c27687b84d0c612a2495e8de110d2d5aa41a8fb3835bade771c524723754"
