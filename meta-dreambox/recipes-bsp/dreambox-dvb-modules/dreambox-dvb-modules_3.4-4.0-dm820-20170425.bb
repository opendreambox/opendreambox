require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "cc22acd18865efcf0edeadb6b0c12934"
SRC_URI[dm820.sha256sum] = "50b696033090759768aa8590b2086f7055f3e0e7f3f4d585475ed8885ab69852"
