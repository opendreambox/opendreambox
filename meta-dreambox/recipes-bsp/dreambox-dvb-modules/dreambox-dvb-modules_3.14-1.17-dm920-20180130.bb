SRC_URI[dm920.md5sum] = "a92de04003998cd13b903e3fde76155c"
SRC_URI[dm920.sha256sum] = "b002c78b4f11d8aa2cffb8feb8101fad6ee4aea7e7f285e866fc914fa43161e9"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
