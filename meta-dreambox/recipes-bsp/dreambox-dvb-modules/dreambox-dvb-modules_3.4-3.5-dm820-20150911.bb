require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "74134fb2a43d7a3e18767c419730311f"
SRC_URI[dm820.sha256sum] = "0d268c10e72ef10a3a7b6df5e419ca75685c935814fab2f0dcfe08f80d9021c7"

COMPATIBLE_MACHINE = "^(dm820)$"
