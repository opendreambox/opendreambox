SRC_URI[dm900.md5sum] = "2b61798081fb6066b2420ac3ae1eed0c"
SRC_URI[dm900.sha256sum] = "fd93b3142b074dfdc42094f4aa9c9b392e924dfaa60843a418bcfd08d3d34b27"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
