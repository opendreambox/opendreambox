SRC_URI[dm900.md5sum] = "ea92f82a7c4e09ef620999ca5365daf5"
SRC_URI[dm900.sha256sum] = "202685660e7d6cd6342e321639b41aa86cc7f5a178af04757716be7970542f73"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
