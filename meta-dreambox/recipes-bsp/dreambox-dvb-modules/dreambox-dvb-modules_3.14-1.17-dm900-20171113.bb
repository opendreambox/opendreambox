SRC_URI[dm900.md5sum] = "ee1fa51128931edfc078c5fee836254b"
SRC_URI[dm900.sha256sum] = "480cc75e30a19ef01c439b76bf5c65cd0a81e79f010c23e4b36fa2db17640491"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
