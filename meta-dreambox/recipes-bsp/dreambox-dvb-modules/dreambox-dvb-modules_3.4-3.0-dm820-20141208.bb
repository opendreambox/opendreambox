require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "553041f73d18e3c327a48718b9d6464f"
SRC_URI[dm820.sha256sum] = "eb5a31fb9be0c5cf4a4fb664de660aa7fbbb5f59be14333008858eb82f3954de"

COMPATIBLE_MACHINE = "^(dm820)$"
