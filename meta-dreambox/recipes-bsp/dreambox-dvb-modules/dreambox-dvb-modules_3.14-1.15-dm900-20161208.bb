SRC_URI[dm900.md5sum] = "379ff74189fe19bc8888c60d16fdb705"
SRC_URI[dm900.sha256sum] = "dcba0de4653a7cb47541b9a50a855674a82dffc7887eac2676ea4aee8fe67369"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
