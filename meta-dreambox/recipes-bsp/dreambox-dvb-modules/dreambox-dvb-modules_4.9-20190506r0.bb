SRC_URI[dreamone.md5sum] = "5832143e9c22011fada1efcbd8e83be3"
SRC_URI[dreamone.sha256sum] = "1bb9f8579940c2ebf16487d0b8a28dd77255f249f2c1166885f8f3a474c7bf96"

require dreambox-dvb-modules.inc
