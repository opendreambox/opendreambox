require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm900.md5sum] = "8f35d1b8d64f0289a299c89ea5e4c7eb"
SRC_URI[dm900.sha256sum] = "dad133b7d244a1148e6c84b2c5a886ab7ccb227d9aa75bef9d75098766c10611"

COMPATIBLE_MACHINE = "^(dm900)$"
