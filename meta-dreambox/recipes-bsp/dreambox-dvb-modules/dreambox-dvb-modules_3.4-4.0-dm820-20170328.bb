require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "107552857b3e7d643b72c17bf8a4dd34"
SRC_URI[dm820.sha256sum] = "dcf15fcf27a24b7a21dc9f915dbda32bb9d889ff70b55790b51a166db5365631"
