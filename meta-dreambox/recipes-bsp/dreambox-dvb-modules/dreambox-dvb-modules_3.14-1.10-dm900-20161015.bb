require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm900.md5sum] = "58506f68c5d98f6cbc664214d766add7"
SRC_URI[dm900.sha256sum] = "92eacc7f07522a430cdca90fac7dfa3c5038809de0724d7556776a551e1ed702"

COMPATIBLE_MACHINE = "^(dm900)$"
