SRC_URI[dm900.md5sum] = "f80a1d3dce6a9a2d016ac1391060e240"
SRC_URI[dm900.sha256sum] = "d8f9991bc7356aa5ce1f1f7ea322da4083c80f2f8f405d4198f420885db2e86d"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
