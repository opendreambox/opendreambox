SRC_URI[dm920.md5sum] = "3c03f42420545051c9964ed8a2221e23"
SRC_URI[dm920.sha256sum] = "1d35004af9dffc4bce5b9181d5d1a34fef2f69dbc12361459eaca8af09413167"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
