SRC_URI[dm900.md5sum] = "cb3789a1b6bfc62781d4fd5d2cb3f7fa"
SRC_URI[dm900.sha256sum] = "de1ece69d951081f07571d8a626f2fc47d8f2ecadb10b415ec493531c4a84717"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
