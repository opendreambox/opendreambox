SRC_URI[dreamone.md5sum] = "1862fab9c87228f45b0575207b499a2d"
SRC_URI[dreamone.sha256sum] = "3a771ce275952c86d9081eb2ded470aac4e8a2f0a4f113bcdcab1e38144e1cae"

require dreambox-dvb-modules.inc
