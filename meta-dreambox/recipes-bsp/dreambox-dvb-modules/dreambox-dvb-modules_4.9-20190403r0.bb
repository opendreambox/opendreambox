SRC_URI[dreamone.md5sum] = "9db01e8b59b0b2a0ea549bcfc63f922d"
SRC_URI[dreamone.sha256sum] = "8238f07cfadc1ed9cf2f715d66614ec304b9a6f3b05f7b9731842d1caf63e167"

require dreambox-dvb-modules.inc
