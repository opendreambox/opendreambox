SRC_URI[dm920.md5sum] = "1a21c1f5c8feb7ab664d8d0ad8da72f0"
SRC_URI[dm920.sha256sum] = "a09223985e26f85536e84ebe8973945979424771ad4a171ebc6080a6a44129b3"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
