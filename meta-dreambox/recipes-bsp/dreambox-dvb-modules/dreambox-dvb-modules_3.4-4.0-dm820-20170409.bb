require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "6321b5e3c3c7dfecf1c1b369b83c39aa"
SRC_URI[dm820.sha256sum] = "9d74a1f096514fbca21f6286e489bc64d3d1431b9e5e1129b7101628502ba810"
