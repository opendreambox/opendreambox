SRC_URI[dm900.md5sum] = "7b0dd4d930315d365a67aa1419ac54ac"
SRC_URI[dm900.sha256sum] = "ef6e1c9bc17ef98124e1d45a20cb88c996b4d1525def7f4f236bd8745f0320be"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
