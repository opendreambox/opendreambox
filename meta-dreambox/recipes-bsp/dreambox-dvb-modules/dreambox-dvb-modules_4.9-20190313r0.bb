SRC_URI[dreamone.md5sum] = "fe6c633d28d1dfc92ea9b7f090f9efc2"
SRC_URI[dreamone.sha256sum] = "be71aa358e3ffb6a1196c33d046bb94fb07aa8d66fa6b994bd4cecccbcfc1456"

require dreambox-dvb-modules.inc
