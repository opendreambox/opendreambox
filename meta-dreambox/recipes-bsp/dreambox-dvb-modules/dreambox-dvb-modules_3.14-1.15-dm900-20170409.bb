SRC_URI[dm900.md5sum] = "0fae6aa8b031f718fe3df10b67f91246"
SRC_URI[dm900.sha256sum] = "4d0a3beb2c21b31265c4c1cc6c59a997d27c62b2b87d00241b4180a2fc588625"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
