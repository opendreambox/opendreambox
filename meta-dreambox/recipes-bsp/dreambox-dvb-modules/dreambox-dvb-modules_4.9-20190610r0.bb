SRC_URI[dreamone.md5sum] = "4cb55cd94054d6f4624b36d600db04cd"
SRC_URI[dreamone.sha256sum] = "681d6f962662894caad00babf4b4236cf1964ce18af268ad49700af488030a68"

require dreambox-dvb-modules.inc
