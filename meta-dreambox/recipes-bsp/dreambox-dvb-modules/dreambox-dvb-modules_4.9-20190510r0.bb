SRC_URI[dreamone.md5sum] = "65da5c3de6a79d7ba45807c8ca3af475"
SRC_URI[dreamone.sha256sum] = "880bc6464cb81fe7e0073a6b1e1280980b8d1b568b63182c3c87186da8dba7ee"

require dreambox-dvb-modules.inc
