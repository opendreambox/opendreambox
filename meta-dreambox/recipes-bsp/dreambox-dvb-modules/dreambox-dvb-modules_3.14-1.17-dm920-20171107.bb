SRC_URI[dm920.md5sum] = "44691a296eb48a51362ce4a474b8d7b0"
SRC_URI[dm920.sha256sum] = "1b4cd84a6b751755bed494b0711e32ddc9c3bd493965029a14728b86c1dd5719"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
