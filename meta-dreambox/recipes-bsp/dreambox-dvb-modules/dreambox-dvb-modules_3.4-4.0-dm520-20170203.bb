require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm520.md5sum] = "6f2d8c960753e5d2c81018bece779d54"
SRC_URI[dm520.sha256sum] = "a26de84654c6e422359ad4d4cd6690e2521059b45f53b73c9d65dec18c7ca4b4"
