SRC_URI[dm900.md5sum] = "6bf8552306f518af4aaf0a700f3a05f3"
SRC_URI[dm900.sha256sum] = "a03d7d1282ec40a2e1e417960f980ecd494dc23346c99412a07a63dc11c43fc6"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
