require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "b6256c79f6266b983430c23683131ba8"
SRC_URI[dm820.sha256sum] = "eec5ea996fedcd2b3a6c997c55df113f7e520cdc515f5c815a572787b1c2350b"

COMPATIBLE_MACHINE = "^(dm820)$"
