SRC_URI[dm900.md5sum] = "e3821e85f92fdadfddf9a8a385fbca1f"
SRC_URI[dm900.sha256sum] = "98e81a0296e8af9e79705f5eba0f5964b952f014769c0886da51a68b3336419c"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
