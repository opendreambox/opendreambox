require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm520.md5sum] = "9ab6c9d7c4aa00ab5b6d26604f9b194b"
SRC_URI[dm520.sha256sum] = "df41041b7abbd8a38e6be6caa31e8413b32bae669c9c8257cec7afb7ca72dda4"
