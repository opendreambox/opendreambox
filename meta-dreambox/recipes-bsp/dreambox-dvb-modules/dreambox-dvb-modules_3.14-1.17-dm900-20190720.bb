SRC_URI[dm900.md5sum] = "f347da12079bb6079226f803239646f4"
SRC_URI[dm900.sha256sum] = "5d7129b0fd6e3572676f40f87242a19a620265468586a9fb40c6b082b73e2a9b"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
