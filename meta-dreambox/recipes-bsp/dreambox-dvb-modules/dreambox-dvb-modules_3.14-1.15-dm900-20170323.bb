SRC_URI[dm900.md5sum] = "7595ede8eaa3b2dbfecb47ec66454c0b"
SRC_URI[dm900.sha256sum] = "6f6513ce70d2477909584ccb497342e2934efa477a8e9b4f09914ef983a0a0c3"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
