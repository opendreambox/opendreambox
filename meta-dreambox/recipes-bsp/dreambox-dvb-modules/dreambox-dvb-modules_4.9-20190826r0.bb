SRC_URI[dreamone.md5sum] = "1854b89982146f81f64126350d31b381"
SRC_URI[dreamone.sha256sum] = "377f376de9c62d0486c16760d6a9382c88813b0de6a29ec4f4fd45cb413c8b5e"

require dreambox-dvb-modules.inc
