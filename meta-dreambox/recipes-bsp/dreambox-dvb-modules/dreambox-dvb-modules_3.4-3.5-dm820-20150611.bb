require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "e12b8e763d167375d8f5500e37244cb7"
SRC_URI[dm820.sha256sum] = "09c38069a650e33c76475a7061679bfec10a77779444c4018fc8454f22527270"

COMPATIBLE_MACHINE = "^(dm820)$"
