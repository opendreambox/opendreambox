SRC_URI[dm900.md5sum] = "bce90773722f00c88ca28d15cd45b5d2"
SRC_URI[dm900.sha256sum] = "cddc1ad738fddcd679e5a7f58f44b965f713b5d48735b50e1dbbc338b9b8bec7"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
