SRC_URI[dm900.md5sum] = "4151d06c5e4eab588c1c6e79c83b7395"
SRC_URI[dm900.sha256sum] = "84077c78df7583e45320d16ff649e066b1a955730a76044c422d72de1009e384"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
