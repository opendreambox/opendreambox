SRC_URI[dm920.md5sum] = "101ff0ba3caebd0a7f8f2bddaff05313"
SRC_URI[dm920.sha256sum] = "32d20cd62db357f23de34affde7a1d125164561a4a935fe5e08b24bb6b172e30"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
