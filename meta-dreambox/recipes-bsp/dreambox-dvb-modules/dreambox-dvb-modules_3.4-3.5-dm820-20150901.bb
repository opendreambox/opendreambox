require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "bdc8adb7d4d9d644153e753d39686c96"
SRC_URI[dm820.sha256sum] = "84953851d3bc32ff210ff082407b8dc190ae19a5fa97b1112c22ad99bf054ca1"

COMPATIBLE_MACHINE = "^(dm820)$"
