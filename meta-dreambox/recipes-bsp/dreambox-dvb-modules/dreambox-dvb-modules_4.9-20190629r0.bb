SRC_URI[dreamone.md5sum] = "5993ecd98b5a074429683eedd04c1e79"
SRC_URI[dreamone.sha256sum] = "786b9b4c8078bef29a557ab55f47de78f4e03cc1751404243ece4945effbc3c8"

require dreambox-dvb-modules.inc
