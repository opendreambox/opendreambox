SRC_URI[dreamone.md5sum] = "ab127e8bb07bbea4cc4fafe7cff2e6af"
SRC_URI[dreamone.sha256sum] = "f4c7e708dd07836f64fb225759ab2842741646f1b6a209c95da0eb5ee2d59fb0"

require dreambox-dvb-modules.inc
