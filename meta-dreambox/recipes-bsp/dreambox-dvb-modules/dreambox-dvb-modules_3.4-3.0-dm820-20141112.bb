require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "588635b2b163a3f8bef7a1e0285ea34a"
SRC_URI[dm820.sha256sum] = "4d202f421453ac21d3ef9a0fd0db3845ef3e05b1c8b08afd82d72b92c15b43ed"

COMPATIBLE_MACHINE = "^(dm820)$"
