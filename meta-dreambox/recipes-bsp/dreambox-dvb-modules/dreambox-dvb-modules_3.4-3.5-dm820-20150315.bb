require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "55c317f95e81e30ba79414ad886bf4ca"
SRC_URI[dm820.sha256sum] = "ca584ec6857b2a0b74d1676c5daf61e9f3e10cbafc229a03a0661cb71b6b2dc8"

COMPATIBLE_MACHINE = "^(dm820)$"
