SRC_URI[dreamone.md5sum] = "042735c7807b1985a8776cbacd0d03fa"
SRC_URI[dreamone.sha256sum] = "9a8342f816bcc3a03515c7d99b5fb8fecfca6af5099078e2a52ae2bd40dc1cb1"

require dreambox-dvb-modules.inc
