SRC_URI[dm900.md5sum] = "657509873ba57bf02079d80b3080300f"
SRC_URI[dm900.sha256sum] = "44c368dba6555cae4a6d289221302949e5a6455baaee7977a128238369614816"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
