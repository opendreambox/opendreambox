SRC_URI[dm900.md5sum] = "73852cdd1b2fc32e3f22a2bdcad6f06e"
SRC_URI[dm900.sha256sum] = "85e2bc17a5bb7f9b50a64a77db397f07327840e2f43c2fdcc8c57711116e9ec9"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
