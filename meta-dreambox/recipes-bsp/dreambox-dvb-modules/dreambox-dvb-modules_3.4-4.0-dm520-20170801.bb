require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm520.md5sum] = "d21dc6b90fe4ff802a6ecbbbb0c1f6d1"
SRC_URI[dm520.sha256sum] = "d4d3fddbaff2430eb26503d256bfbe102943147929525efaca69cac8bcc7b15e"
