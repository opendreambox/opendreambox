SRC_URI[dm900.md5sum] = "b12caad8e61a55aefcdbb414c4fa9197"
SRC_URI[dm900.sha256sum] = "415b1b705cfdd067828f36306ca5016cb465a6141e58f653cd3be942a2354f04"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
