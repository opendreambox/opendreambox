require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm520.md5sum] = "3f80bb4d6780e0c84faa4558c011a715"
SRC_URI[dm520.sha256sum] = "d7c15e345ddd8b15459719cc3c166ec93681fad04712faa8126b34d9e9f7a3a6"

COMPATIBLE_MACHINE = "^(dm520)$"
