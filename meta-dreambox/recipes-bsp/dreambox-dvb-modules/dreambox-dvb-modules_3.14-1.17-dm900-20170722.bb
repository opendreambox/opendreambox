SRC_URI[dm900.md5sum] = "af0879ae80a42f56ff99a2a002e8a5e1"
SRC_URI[dm900.sha256sum] = "64fcb9e8c0436b540817d29867df148a5b6cb9ac0c0817c78dabadec7c260978"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
