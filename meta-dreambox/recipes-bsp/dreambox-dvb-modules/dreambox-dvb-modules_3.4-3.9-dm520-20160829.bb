require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm520.md5sum] = "aa053da9676fa346334878a42d939145"
SRC_URI[dm520.sha256sum] = "7a65254fb631b9d1db0094a85470036f435ce57c0740d3ff0127d7ddd34317fd"

COMPATIBLE_MACHINE = "^(dm520)$"
