require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "9594b8c2a2d498e564e4f70d39545f16"
SRC_URI[dm820.sha256sum] = "515f9a061b04be883eb2e61abf7ecdd28b4f82b702250f5ddbb023e204e42adb"

COMPATIBLE_MACHINE = "^(dm820)$"
