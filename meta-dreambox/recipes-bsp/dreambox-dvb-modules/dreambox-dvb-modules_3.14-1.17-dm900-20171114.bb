SRC_URI[dm900.md5sum] = "c9a31ae67dfe36ddc73eeae8de1a9415"
SRC_URI[dm900.sha256sum] = "500ea488397f0fa234af4fbdc21c03911fdcf6df5e83073cb21d758c13755b8d"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
