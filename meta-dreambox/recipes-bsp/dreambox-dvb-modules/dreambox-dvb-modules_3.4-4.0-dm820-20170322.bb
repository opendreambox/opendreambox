require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "55d10cd99647a360676b84c874f48036"
SRC_URI[dm820.sha256sum] = "9ded513ce99eee94010d7df5fb670bd3d320a075e73dbaf219aa2137b78f62f2"
