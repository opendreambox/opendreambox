require dreambox-dvb-modules.inc

SRC_URI[modules.md5sum] = "66c4ec5416037475ef84345b30a58e57"
SRC_URI[modules.sha256sum] = "7a03d1e311019a3527b6c1bf1685fef91688de08b7e472ddfdac6832f84996a4"

COMPATIBLE_MACHINE = "^(dm7080)$"
