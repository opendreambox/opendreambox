SRC_URI[dm900.md5sum] = "0e7ebe0aa2480bf6989f6b2b3aac80e0"
SRC_URI[dm900.sha256sum] = "b8930f1978f359ec81c48dd7379d2b868d8fff3382c91e8dc2b270bd77b04c21"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
