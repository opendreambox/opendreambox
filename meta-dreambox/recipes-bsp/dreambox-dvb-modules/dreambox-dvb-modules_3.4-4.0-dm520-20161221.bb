require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm520.md5sum] = "081fb795260cd106397890e6e57f5c8b"
SRC_URI[dm520.sha256sum] = "a535600765952212e7eb8a126f435b0c748a57c3c44b995462947329558996fa"
