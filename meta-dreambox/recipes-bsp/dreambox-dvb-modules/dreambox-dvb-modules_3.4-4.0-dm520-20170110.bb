require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm520.md5sum] = "41d4b1cacd67b64009860e191ba06899"
SRC_URI[dm520.sha256sum] = "e04dbbc411620fe9cb8e4f4d430cedc684a31a4c504bcf64893ea029205376fa"
