SRC_URI[dm920.md5sum] = "e790932031d2093aaabfdd97394ab356"
SRC_URI[dm920.sha256sum] = "1b470128a09c0d36b33f43c6a9b4c6f7aa89d34b11bc029167d9c7259fa1b617"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
