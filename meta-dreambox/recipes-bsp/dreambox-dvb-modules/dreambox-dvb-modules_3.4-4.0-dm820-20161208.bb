require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc

SRC_URI[dm820.md5sum] = "bc6b3f0c1b5c1d9c5a9dc3047dbaa1ad"
SRC_URI[dm820.sha256sum] = "1c53efca9d19801c567fe871bab285c68e28a19db018c79cb611cb7a81ee4267"
