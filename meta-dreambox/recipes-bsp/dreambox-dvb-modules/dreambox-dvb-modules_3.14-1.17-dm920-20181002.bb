SRC_URI[dm920.md5sum] = "979fda4563a4b07c4357a2a7cf5cc9f2"
SRC_URI[dm920.sha256sum] = "daf623511188760253471df4c4adb1197412e316f82a519e5fabda887ca45ddd"

require recipes-bsp/dreambox-dvb-modules/dreambox-dvb-modules.inc
