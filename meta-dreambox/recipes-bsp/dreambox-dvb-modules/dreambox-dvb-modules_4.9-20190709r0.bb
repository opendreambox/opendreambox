SRC_URI[dreamone.md5sum] = "57b43917b240661e4b0fe1218af58d12"
SRC_URI[dreamone.sha256sum] = "96beb0f55cba347243e92c3af385d7d4425a9b5c8935ad87d318c90c659f3712"

require dreambox-dvb-modules.inc
