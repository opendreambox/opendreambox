SRC_URI[dreamone.md5sum] = "35d78d797c4a3f2bf8f2d70f801407b2"
SRC_URI[dreamone.sha256sum] = "e102bbe087b6676f3b9a06881232668e5b787da15a4083f3631dcf10f3a5f606"

inherit opendreambox-precompiled-binary

require u-boot-bin.inc
