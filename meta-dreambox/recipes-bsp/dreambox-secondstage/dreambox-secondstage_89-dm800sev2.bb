require dreambox-secondstage.inc

SRC_URI[md5sum] = "b8f5cf53fc8cae8fbeca74ceee60d734"
SRC_URI[sha256sum] = "d4d683022cfb405fe63820ae2e159408a6b01b6a037928e3d9e39bdfc27efad5"

COMPATIBLE_MACHINE = "^(dm800sev2)$"
